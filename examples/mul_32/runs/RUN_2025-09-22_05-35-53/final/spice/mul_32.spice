* NGSPICE file created from mul_32.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

.subckt mul_32 A[0] A[10] A[11] A[12] A[13] A[14] A[15] A[16] A[17] A[18] A[19] A[1]
+ A[20] A[21] A[22] A[23] A[24] A[25] A[26] A[27] A[28] A[29] A[2] A[30] A[31] A[3]
+ A[4] A[5] A[6] A[7] A[8] A[9] B[0] B[10] B[11] B[12] B[13] B[14] B[15] B[16] B[17]
+ B[18] B[19] B[1] B[20] B[21] B[22] B[23] B[24] B[25] B[26] B[27] B[28] B[29] B[2]
+ B[30] B[31] B[3] B[4] B[5] B[6] B[7] B[8] B[9] C[0] C[10] C[11] C[12] C[13] C[14]
+ C[15] C[16] C[17] C[18] C[19] C[1] C[20] C[21] C[22] C[23] C[24] C[25] C[26] C[27]
+ C[28] C[29] C[2] C[30] C[31] C[32] C[33] C[34] C[35] C[36] C[37] C[38] C[39] C[3]
+ C[40] C[41] C[42] C[43] C[44] C[45] C[46] C[47] C[48] C[49] C[4] C[50] C[51] C[52]
+ C[53] C[54] C[55] C[56] C[57] C[58] C[59] C[5] C[60] C[61] C[62] C[63] C[6] C[7]
+ C[8] C[9] VGND VPWR clk
XFILLER_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05903_ net439 net346 net224 net183 VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__and4_1
X_06883_ _00737_ _00738_ _00718_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__a21oi_1
X_09671_ _03625_ _03780_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__nand2b_1
XFILLER_94_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08622_ _02634_ _02635_ _02636_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nand3_1
X_05834_ _04964_ _04965_ _04966_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__nand3_2
X_08553_ net383 net308 net293 net464 VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_53_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05765_ _04863_ _04864_ _04897_ _04898_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__or4bb_1
X_07504_ _01413_ _01414_ _01412_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__o21ai_1
X_08484_ _02465_ _02484_ _02485_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__nand3_2
X_07435_ _01320_ _01339_ _01340_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__and3_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05696_ _03417_ _03788_ _03777_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__a21bo_1
XFILLER_23_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07366_ _01264_ _01265_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__or2_1
XFILLER_108_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07297_ _01186_ _01188_ _01031_ _01034_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__o211ai_2
X_06317_ _00135_ _00136_ VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__xor2_1
X_09105_ _03161_ _03162_ _03163_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__a21o_1
X_06248_ _00046_ _00067_ _00068_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__nor3_1
X_09036_ net177 net305 net290 net221 VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__a22o_1
XFILLER_104_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06179_ net254 net172 VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__nand2_1
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09938_ _04068_ _04069_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__xnor2_1
X_09869_ net175 net243 VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__nand2_1
XFILLER_58_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10644_ _04831_ _04832_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__nor2_1
X_10575_ _04757_ _04758_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__xnor2_1
XFILLER_42_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10009_ net338 net530 _04145_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__a22o_1
XFILLER_36_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05550_ _02348_ _02435_ _02424_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_67_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05481_ _01791_ _01813_ _01780_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__o21ba_1
X_07220_ _01106_ _01105_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__and2b_1
X_07151_ _01027_ _01029_ _01030_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__a21o_1
XFILLER_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06102_ _05136_ _05138_ _05230_ _05231_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__o211ai_2
XFILLER_8_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07082_ _00814_ _00816_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__nand2_1
X_06033_ _05157_ _05162_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__or2_1
XFILLER_99_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07984_ net178 net369 _01938_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__a22o_1
X_06935_ net491 net333 net326 net498 VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__a22o_1
XFILLER_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09723_ _03685_ _03688_ _03836_ _03837_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__a211o_1
XFILLER_95_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06866_ net216 net617 VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nand2_1
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09654_ net583 net312 VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__nand2_1
XFILLER_103_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08605_ _02484_ _02486_ net157 _02617_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_38_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05817_ _04940_ _04948_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__xnor2_1
X_06797_ net611 net318 VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__nand2_1
XFILLER_70_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09585_ net297 net242 VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__nand2_1
XFILLER_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08536_ net457 net263 _02540_ _02541_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__o2bb2a_1
X_05748_ net439 net346 net386 net300 VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__and4_1
X_08467_ net401 net593 VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__nand2_1
XFILLER_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05679_ net349 net467 net386 net33 VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__a22oi_2
X_08398_ net482 net251 _02389_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__nand3_1
X_07418_ net236 net233 net574 net567 VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__and4_1
XFILLER_50_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07349_ _01085_ _01088_ _01244_ _01247_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_94_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10360_ _04527_ _04528_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__nor2_1
X_09019_ _03067_ _03068_ net549 net263 VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__and4bb_1
X_10291_ _04309_ _04453_ _04454_ _04379_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__o22ai_1
XFILLER_104_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10627_ _04789_ _04793_ _04814_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__o21a_1
X_10558_ _04695_ _04700_ _04739_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__a21oi_1
X_10489_ _04665_ _04666_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_114_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06720_ _00559_ _00561_ _00544_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__a21o_1
XFILLER_77_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06651_ _00486_ _00487_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__or2_1
XFILLER_76_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05602_ _03439_ _03494_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__nand2b_1
X_06582_ _00410_ _00411_ VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__nor2_1
X_09370_ _03332_ _03335_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__nor2_1
X_08321_ _02305_ _02306_ _02307_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__or3_1
X_05533_ _02654_ _02741_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__nand2b_1
X_08252_ _02230_ _02231_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__xnor2_1
X_05464_ _01867_ _01878_ _01988_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__nor3_2
X_07203_ _01086_ _01087_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_43_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08183_ _01992_ _01994_ _01993_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__o21bai_1
X_05395_ _01224_ _01235_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__and2_1
X_07134_ net215 net595 VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__nand2_1
XFILLER_118_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07065_ _00917_ _00936_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__xnor2_1
X_06016_ _05144_ _05145_ _04996_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__a21o_1
XFILLER_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07967_ _01919_ _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__and2b_1
XFILLER_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06918_ _00777_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__inv_2
XFILLER_87_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09706_ _03818_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__inv_2
X_07898_ _01843_ _01844_ _01666_ _01669_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__a211o_1
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06849_ _00700_ _00701_ _00685_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09637_ net376 net513 VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__nand2_1
XFILLER_43_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09568_ _03561_ _03665_ _03666_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__and3_1
X_08519_ _02377_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__xnor2_1
XFILLER_23_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09499_ _03582_ _03591_ _03593_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__and3_1
XFILLER_23_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10412_ _04503_ _04566_ _04565_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__o21ai_2
XFILLER_109_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10343_ _04368_ _04437_ _04439_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__o21ai_1
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10274_ _04389_ _04435_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__nor2_1
XFILLER_105_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout491 net492 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__buf_2
XFILLER_93_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout480 net481 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__clkbuf_2
XFILLER_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08870_ net186 net430 net533 net527 VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__nand4_1
X_07821_ _01751_ _01761_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__xnor2_2
XFILLER_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07752_ _01684_ _01685_ _01401_ _01403_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__a211oi_1
X_07683_ net416 net408 net166 net625 VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__and4_1
X_06703_ _00432_ _00441_ _00439_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_48_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06634_ _00428_ _00431_ _00467_ _00468_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__nor4_1
XFILLER_80_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09422_ _03268_ _03391_ _03509_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__a21o_1
XFILLER_52_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09353_ _03430_ _03431_ _03432_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__nand3_1
X_06565_ _00391_ _00392_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__nor2_1
X_08304_ _02285_ _02286_ _02287_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__a21oi_1
X_06496_ net197 net301 VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__nand2_1
X_05516_ _02534_ _02544_ _02173_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__a21oi_1
X_09284_ _03356_ _03357_ _03349_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__a21o_1
XFILLER_119_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08235_ _02069_ _02090_ _02089_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__a21boi_1
X_05447_ net493 net217 VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__nand2_1
XFILLER_118_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08166_ _02135_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__xnor2_1
X_05378_ _01039_ _01050_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__nor2_1
XFILLER_119_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07117_ _00983_ _00992_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__xnor2_1
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08097_ _02060_ _02061_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__xor2_1
XFILLER_69_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07048_ net520 net318 _00797_ _00796_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__a31o_1
XFILLER_79_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08999_ _03040_ _03046_ _03048_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__nand3_1
XFILLER_56_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire144 _02968_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_1
XFILLER_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10326_ _04490_ _04491_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_111_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10257_ _04414_ _04415_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__xnor2_1
X_10188_ net306 net296 net560 net545 VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__nand4_2
XFILLER_39_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06350_ _00086_ _00089_ _00167_ _00169_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__a211oi_2
X_06281_ net216 net224 VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__nand2_1
XFILLER_30_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08020_ _01978_ _01979_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__and2_1
XFILLER_116_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09971_ _04104_ _04105_ _04063_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__a21o_1
X_08922_ _02961_ _02963_ _02813_ _02815_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__o211a_1
XFILLER_111_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08853_ _02778_ _02780_ _02887_ _02888_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__o211ai_4
X_07804_ _01700_ _01741_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__xor2_1
X_08784_ _02811_ _02812_ _02795_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a21o_1
X_05996_ _05123_ _05124_ _05125_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_88_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07735_ net158 _01665_ _01498_ _01501_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__o211ai_2
XFILLER_72_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07666_ net302 net373 _01590_ _01591_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__nand4_1
XFILLER_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09405_ _03445_ _03446_ _03489_ _03490_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__and4bb_1
XFILLER_111_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07597_ _01245_ _01248_ _01516_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__a211oi_2
XFILLER_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06617_ net440 net347 net595 net587 VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__and4_1
XFILLER_13_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06548_ _00372_ _00373_ VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__and2b_1
X_09336_ _03294_ _03295_ _03293_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_23_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09267_ net466 net253 VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__and2_1
X_08218_ _01917_ _02020_ _02019_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__a21oi_1
X_06479_ net553 net426 VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__nand2_1
XFILLER_119_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09198_ _02041_ _02044_ _02045_ _02692_ _03261_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__a311o_4
XFILLER_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08149_ _02117_ _02118_ _02114_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__a21o_1
XFILLER_20_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10111_ _04256_ _04257_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__xnor2_1
XFILLER_88_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10042_ net573 net307 net566 net292 VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__nand4_2
XFILLER_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_5 net14 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10309_ _04470_ _04471_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__xor2_1
XFILLER_98_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05850_ _04981_ _04982_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__nor2_2
XFILLER_66_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07520_ _01432_ _01433_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__or2_1
X_05781_ _04624_ _04912_ _04913_ _04914_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__o211ai_2
X_07451_ _01199_ _01201_ _01357_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__a211oi_1
X_07382_ _01150_ _01152_ _01281_ _01282_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_83_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06402_ _00218_ _00219_ _00220_ VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__a21o_1
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06333_ net521 net371 _00055_ _00053_ VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_20_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09121_ _03179_ _03180_ _03172_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__a21o_1
X_06264_ _00075_ _00083_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__xnor2_1
X_09052_ _02964_ _02966_ _03105_ _03106_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__o211ai_4
X_08003_ net401 net622 VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__nand2_1
X_06195_ _05222_ _05225_ _00014_ _00016_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__a211oi_4
XFILLER_104_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09954_ net588 net284 _04085_ _04086_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__nand4_2
XFILLER_112_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08905_ net400 net579 _02798_ _02797_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__a31o_1
X_09885_ _03910_ _03912_ _04011_ _04012_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__a211oi_2
X_08836_ net385 net286 _02868_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__a22o_1
XFILLER_85_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08767_ _02646_ _02656_ _02655_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__a21bo_1
X_05979_ net453 net195 _05107_ _05108_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__nand4_1
XFILLER_72_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08698_ net464 net286 _02716_ _02717_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_56_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07718_ net345 net510 VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07649_ net458 net317 VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__nand2_1
XFILLER_26_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10660_ _04848_ _04849_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__or2_1
X_09319_ _03394_ _03396_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__and2b_1
X_10591_ net523 net248 VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__nand2_1
XFILLER_21_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput75 net75 VGND VGND VPWR VPWR C[19] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput86 net86 VGND VGND VPWR VPWR C[29] sky130_fd_sc_hd__buf_2
XFILLER_95_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput97 net97 VGND VGND VPWR VPWR C[39] sky130_fd_sc_hd__buf_2
X_10025_ net583 net276 net268 net591 VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__a22oi_1
XFILLER_91_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout309 net311 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_2
XFILLER_99_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06951_ net552 net396 net379 net448 VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__a22o_1
XFILLER_79_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09670_ _03776_ _03778_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05902_ net254 net300 VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__nand2_1
X_06882_ _00718_ _00737_ _00738_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__nand3_1
X_08621_ _02473_ _02475_ _02474_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__o21bai_1
XFILLER_39_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05833_ _04880_ _04888_ _04887_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__a21bo_1
X_08552_ net464 net383 net308 net293 VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__nand4_2
XFILLER_35_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05764_ _04894_ _04896_ _04440_ _04461_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__o211ai_1
X_07503_ _01412_ _01413_ _01414_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__or3_1
X_08483_ _02482_ _02483_ _02466_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07434_ _01336_ _01337_ _01338_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__a21o_1
XFILLER_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05695_ _04136_ _04505_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07365_ _01254_ _01263_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_33_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07296_ _01031_ _01034_ _01186_ _01188_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__a211o_1
X_06316_ _00135_ _00136_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__or2_1
X_09104_ net598 net336 VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__and2_1
X_06247_ _00064_ _00066_ _05287_ _05290_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__o211a_1
X_09035_ net221 net177 net305 net290 VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__nand4_2
XFILLER_116_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06178_ _05303_ _05306_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09937_ _03983_ _03986_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__nor2_1
XFILLER_98_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09868_ _03992_ _03993_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08819_ _02848_ _02849_ net445 net263 VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__and4bb_1
XFILLER_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09799_ _03917_ _03918_ _03814_ _03816_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__a211o_1
XFILLER_60_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10643_ _04829_ _04830_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__and2_1
X_10574_ _04757_ _04758_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__nand2b_1
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10008_ net353 net514 net506 net361 VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__a22o_1
XFILLER_64_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05480_ _02151_ _02162_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_80_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07150_ _01027_ _01029_ _01030_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_30_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07081_ _00945_ _00954_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__xnor2_1
X_06101_ _05227_ _05228_ _05194_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06032_ _05160_ _05161_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__nor2_1
X_07983_ net170 net377 net162 net393 VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__a22o_1
XFILLER_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09722_ _03834_ _03835_ _03724_ _03726_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__o211a_1
X_06934_ net491 net498 net333 net327 VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__and4_1
X_06865_ _00719_ _00720_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__nor2_1
X_09653_ _03759_ _03760_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__and2b_1
XFILLER_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08604_ _02612_ _02614_ _02598_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__o21a_1
X_09584_ _03683_ _03684_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__xor2_1
XFILLER_27_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05816_ _04940_ _04948_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06796_ _00643_ _00644_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__nor2_1
XFILLER_103_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08535_ net443 net279 net271 net450 VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__a22oi_1
XFILLER_70_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05747_ net254 net467 VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__nand2_1
X_08466_ _02321_ _02330_ _02329_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__a21bo_1
XFILLER_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05678_ net33 net349 net467 net386 VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__and4_1
X_08397_ net482 net251 VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__nand2_1
X_07417_ net215 net580 VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__nand2_1
XFILLER_23_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07348_ _01242_ _01243_ _01129_ _01131_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__a211oi_1
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07279_ net256 net567 VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__and2_1
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09018_ net549 net263 _03067_ _03068_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__o2bb2a_1
X_10290_ _04306_ _04380_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__nor2_1
XFILLER_104_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10626_ _04801_ _04812_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10557_ _04695_ _04700_ _04739_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__and3_1
X_10488_ _04665_ _04666_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_114_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06650_ _00483_ _00485_ _00256_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_69_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_663 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05601_ _03472_ _03483_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__xnor2_1
X_06581_ net553 net418 net410 net449 VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__a22oi_1
XFILLER_64_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08320_ net427 net575 net564 net184 VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__a22oi_2
X_05532_ _02665_ _02719_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__xnor2_1
X_08251_ net496 net246 VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__nand2_1
X_05463_ _01497_ _01966_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__xnor2_1
X_07202_ net632 net281 VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08182_ _01983_ _01986_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__nand2_1
X_05394_ _00287_ _00658_ _00636_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__a21o_1
XFILLER_118_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07133_ _01001_ _01010_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__xnor2_1
X_07064_ _00936_ _00917_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06015_ _04996_ _05144_ _05145_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__nand3_2
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07966_ net465 net332 net325 net548 VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__a22o_1
XFILLER_75_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06917_ net608 net630 net310 net295 VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__and4_1
XFILLER_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09705_ _03704_ _03706_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__a211o_1
X_07897_ _01666_ _01669_ _01843_ _01844_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__o211ai_2
X_09636_ net376 net514 VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__and2_1
XFILLER_83_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06848_ _00685_ _00700_ _00701_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06779_ _00489_ _00627_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__xor2_1
XFILLER_55_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09567_ _03665_ _03666_ _03561_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08518_ _02520_ _02521_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__xnor2_1
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09498_ _03589_ _03590_ _03583_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__a21o_1
X_08449_ net369 net621 _02444_ _02445_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__nand4_1
XFILLER_11_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10411_ _04580_ _04584_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10342_ _04434_ _04509_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10273_ _04431_ _04432_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__xnor2_1
XFILLER_93_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout470 net3 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__clkbuf_4
Xfanout492 net27 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_2
Xfanout481 net28 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__buf_2
XFILLER_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10609_ _04796_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_23_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07820_ _01759_ _01760_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__and2b_1
XFILLER_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07751_ _01401_ _01403_ _01684_ _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__o211a_1
X_06702_ _00540_ _00541_ _00401_ _00403_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__o211a_1
X_07682_ net401 net174 VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_48_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06633_ _00464_ _00466_ _00343_ _00346_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__o211a_1
XFILLER_65_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09421_ _03257_ _03389_ _03390_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_32_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06564_ net461 net396 net379 net476 VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__a22oi_1
X_09352_ _03430_ _03431_ _03432_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__and3_1
X_08303_ _02285_ _02286_ _02287_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__and3_1
XFILLER_80_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05515_ _02173_ _02534_ _02544_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__and3_1
X_06495_ _00315_ _00316_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__nor2_1
X_09283_ _03349_ _03356_ _03357_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__nand3_2
X_08234_ _02050_ _02093_ _02092_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__o21ai_1
X_05446_ _01780_ _01791_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nor2_1
XFILLER_119_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08165_ _02136_ _02137_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__and2b_1
X_05377_ net493 net234 net228 net516 VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07116_ _00983_ _00992_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_41_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08096_ net496 net251 _02060_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__nand3_1
XFILLER_69_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07047_ _00799_ _00808_ _00807_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__a21oi_1
XFILLER_87_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08998_ _03044_ _03045_ _03041_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__a21o_1
XFILLER_47_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07949_ _01898_ _01899_ _01892_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__a21o_1
XFILLER_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09619_ _03719_ _03721_ _03564_ _03608_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__o211a_1
XFILLER_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire145 _02668_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_1
XFILLER_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10325_ net577 net249 VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__and2_1
XFILLER_3_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10256_ _04415_ _04414_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__nand2b_1
XFILLER_78_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10187_ net315 net545 _04237_ _04236_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__a31o_1
XFILLER_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06280_ _00091_ _00099_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09970_ _04063_ _04104_ _04105_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__nand3_1
X_08921_ _02813_ _02815_ net155 _02963_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__a211oi_4
X_08852_ _02882_ _02885_ _02864_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__a21o_1
X_07803_ _01700_ _01741_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__nand2_1
XFILLER_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08783_ _02795_ _02811_ _02812_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__nand3_2
X_05995_ _05123_ _05124_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__nand3_1
X_07734_ _01498_ _01501_ net158 _01665_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_88_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07665_ net302 net373 _01590_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__a22o_1
X_06616_ net255 net603 VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__nand2_1
X_09404_ _03487_ _03488_ _03366_ _03368_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__a211o_1
XFILLER_111_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07596_ _01514_ _01515_ _01353_ _01357_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__a211oi_1
X_06547_ _00286_ _00289_ _00371_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__or3b_1
X_09335_ _03410_ _03411_ _03412_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_23_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06478_ _00296_ _00297_ VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__nor2_1
X_09266_ _03336_ _03337_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__xnor2_1
X_08217_ _02094_ _02193_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__xnor2_1
X_05429_ _01246_ _01595_ _01606_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__nand3_1
XFILLER_119_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09197_ _02691_ _03261_ _03263_ _03264_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__o211a_2
XFILLER_112_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08148_ _02114_ _02117_ _02118_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__nand3_1
XFILLER_106_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08079_ _02042_ _05070_ _00772_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__or3b_2
XFILLER_20_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10110_ _04256_ _04257_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__or2_1
XFILLER_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10041_ net315 net566 _04043_ _04042_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__a31o_1
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_6 net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10308_ _04471_ _04470_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_72_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10239_ _04395_ _04397_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__xnor2_1
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05780_ _04602_ _04912_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__or2_1
XFILLER_19_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07450_ _01248_ _01249_ _01354_ _01356_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__a22oi_2
XFILLER_50_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07381_ _01279_ _01280_ _01266_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_83_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06401_ _00218_ _00219_ _00220_ VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__nand3_4
XFILLER_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06332_ _00150_ _00151_ VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__or2_1
XFILLER_50_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09120_ _03172_ _03179_ _03180_ VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__nand3_1
X_09051_ _03103_ _03104_ _03084_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__a21o_1
XFILLER_30_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08002_ _01958_ _01959_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__and2b_1
X_06263_ _00075_ _00083_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06194_ _00012_ _00013_ _05302_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__a21oi_2
XFILLER_116_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09953_ net588 net284 _04085_ _04086_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__a22o_1
XFILLER_85_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08904_ _02761_ _02765_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__nand2_1
X_09884_ _04009_ _04010_ _03999_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08835_ net220 net305 net293 net299 VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__a22o_1
XFILLER_57_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08766_ _02637_ _02639_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__nand2_1
XFILLER_57_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05978_ net453 net195 _05107_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__a22o_1
X_07717_ net256 net536 VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__nand2_1
XFILLER_26_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08697_ net464 net286 _02716_ _02717_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_56_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07648_ _01571_ _01572_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_0_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07579_ _01494_ _01495_ _01496_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__a21o_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09318_ net405 net525 net509 net413 VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__a22o_1
XFILLER_40_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10590_ _04774_ _04775_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__nor2_1
X_09249_ _03303_ _03316_ _03318_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__or3_1
XFILLER_119_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput76 net76 VGND VGND VPWR VPWR C[1] sky130_fd_sc_hd__buf_2
Xoutput65 net65 VGND VGND VPWR VPWR C[0] sky130_fd_sc_hd__buf_2
XFILLER_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput98 net98 VGND VGND VPWR VPWR C[3] sky130_fd_sc_hd__buf_2
Xoutput87 net87 VGND VGND VPWR VPWR C[2] sky130_fd_sc_hd__buf_2
XFILLER_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10024_ net591 net583 net276 net268 VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__and4_1
XFILLER_56_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06950_ net552 net448 net396 net379 VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__nand4_1
XFILLER_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06881_ _00718_ _00737_ _00738_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05901_ _05031_ _05032_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__xnor2_1
XFILLER_94_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08620_ _02630_ _02631_ _02633_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__nand3_1
XFILLER_39_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05832_ _04962_ _04963_ _04955_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__a21o_1
XFILLER_54_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08551_ net383 net316 _02427_ _02426_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__a31o_1
X_05763_ _04440_ _04461_ _04894_ _04896_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__a211o_1
X_07502_ net470 net363 net355 net553 VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__a22oi_2
X_08482_ _02466_ _02482_ _02483_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_53_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05694_ _04483_ _04494_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__nor2_1
X_07433_ _01336_ _01337_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07364_ _01254_ _01263_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__and2_1
XFILLER_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09103_ net350 net592 net584 net358 VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_33_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07295_ _01031_ _01034_ _01186_ _01188_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__a211oi_1
X_06315_ _00027_ _00029_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__nor2_1
X_06246_ _05287_ _05290_ _00064_ _00066_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__a211oi_1
X_09034_ net178 net313 _02930_ _02929_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06177_ _05304_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__nor2_1
XFILLER_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09936_ _04066_ _04067_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__nor2_1
XFILLER_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09867_ _03892_ _03893_ _03891_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__a21oi_1
XFILLER_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08818_ net445 net263 _02848_ _02849_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__o2bb2a_1
X_09798_ _03814_ _03816_ _03917_ _03918_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__o211ai_4
X_08749_ _02758_ _02771_ _02773_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__or3_2
XFILLER_14_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10642_ _04829_ _04830_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__nor2_1
XFILLER_13_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10573_ net555 net243 _04704_ _04703_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__a31o_1
XFILLER_5_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10007_ net361 net353 net514 net505 VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_108_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07080_ _00952_ _00953_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__nor2_1
XFILLER_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06100_ _05194_ _05227_ _05228_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__or3_1
XFILLER_9_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06031_ net1 net373 _05158_ _05159_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_10_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07982_ net393 net170 net377 net161 VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand4_1
X_06933_ net520 net318 VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09721_ _03724_ _03726_ _03834_ _03835_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__a211oi_1
XFILLER_103_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06864_ net232 net603 net595 net239 VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__a22oi_1
XFILLER_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09652_ net321 net576 net569 net329 VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__a22o_1
X_06795_ net498 net334 net327 net520 VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__a22oi_1
XFILLER_94_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08603_ _02598_ _02612_ _02614_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__or3_1
X_09583_ _03683_ _03684_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_38_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05815_ _04941_ _04946_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__xnor2_1
X_08534_ net450 net443 net279 net271 VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__and4_1
X_05746_ _04878_ _04879_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__xnor2_1
X_08465_ _02311_ _02313_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05677_ net257 net550 VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__nand2_1
X_08396_ _02386_ _02387_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__xnor2_1
X_07416_ _01309_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__xor2_1
XFILLER_11_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07347_ _01244_ VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__inv_2
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07278_ _01166_ _01169_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__xnor2_1
X_09017_ net385 net275 net267 net466 VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__a22oi_1
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06229_ _05265_ _00048_ VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__or2_1
XFILLER_2_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout630 net632 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__buf_2
X_09919_ net352 net530 net514 net360 VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__a22o_1
XFILLER_86_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10625_ _04801_ _04812_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__and2b_1
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10556_ _04737_ _04738_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__xor2_1
XFILLER_108_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10487_ _04535_ _04598_ _04619_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_114_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_87_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_675 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05600_ net494 net196 VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__nand2_1
X_06580_ net553 net448 net418 net410 VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__and4_1
XFILLER_52_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_96_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05531_ _02665_ _02719_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__nand2b_1
X_08250_ _02228_ _02229_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__nor2_1
XFILLER_60_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05462_ _01497_ _01966_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_15_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07201_ _01083_ _01084_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__xnor2_1
X_08181_ _02153_ _02154_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__nor2_1
XFILLER_20_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07132_ _01001_ _01010_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__nand2b_1
X_05393_ _01203_ _01214_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__nor2_1
XFILLER_118_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07063_ _00934_ _00935_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__nand2_1
X_06014_ _05142_ _05143_ _05056_ _05058_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__a211o_1
X_07965_ net548 net465 net332 net325 VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__and4_1
XFILLER_59_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06916_ net608 net310 net295 net630 VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__a22o_1
XFILLER_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09704_ _03814_ _03815_ _03698_ _03700_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__o211a_1
X_07896_ _01841_ _01842_ _01807_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__a21o_1
XFILLER_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09635_ _03736_ _03740_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__xnor2_1
XFILLER_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06847_ _00698_ _00699_ _00690_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__a21o_1
XFILLER_55_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06778_ _00624_ _00625_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__and2_1
XFILLER_83_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09566_ _03623_ _03626_ _03663_ _03664_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__a22o_1
XFILLER_36_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08517_ _02520_ _02521_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__or2_1
X_09497_ _03583_ _03589_ _03590_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__nand3_1
X_05729_ _04070_ _04092_ _04856_ _04862_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__a211oi_2
X_08448_ net369 net621 _02444_ _02445_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__a22o_1
XFILLER_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08379_ _02367_ _02368_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__xnor2_1
X_10410_ _04457_ _04583_ _04582_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__o21a_1
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10341_ _04436_ _04508_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__xor2_1
X_10272_ _04433_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__inv_2
XFILLER_105_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout482 net483 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__buf_2
Xfanout460 net463 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__buf_2
XFILLER_58_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout493 net495 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__buf_2
Xfanout471 net473 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__buf_2
XFILLER_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10608_ _04755_ _04759_ _04794_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__nand3_1
XFILLER_10_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10539_ _04687_ _04721_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__xor2_1
XFILLER_111_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07750_ net131 _01681_ _01512_ _01514_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__o211ai_1
XFILLER_96_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06701_ _00401_ _00403_ _00540_ _00541_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__a211oi_1
XFILLER_77_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07681_ _01468_ _01477_ _01476_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_48_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06632_ _00343_ _00346_ _00464_ _00466_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__a211oi_4
X_09420_ _03506_ _03507_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__nor2_1
X_06563_ net476 net461 net396 net379 VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__and4_1
XFILLER_80_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09351_ _03304_ _03312_ _03311_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a21bo_1
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08302_ _02113_ _02121_ _02120_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__a21bo_1
X_05514_ _02501_ _02512_ _01867_ _01999_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__a211o_1
XFILLER_21_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09282_ _03354_ _03355_ _03350_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__a21o_1
XFILLER_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08233_ net519 net246 _02067_ _02066_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__a31o_1
X_06494_ net203 net223 net180 net212 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__a22oi_1
X_05445_ net479 net234 net228 net486 VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08164_ net407 net600 net593 net415 VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__a22o_1
X_05376_ net493 net516 net234 net228 VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__and4_1
XFILLER_118_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08095_ net496 net251 VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__nand2_1
X_07115_ _00989_ _00990_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__xnor2_1
XFILLER_109_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07046_ _00829_ _00831_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__or2_1
XFILLER_88_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08997_ _03041_ _03044_ _03045_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__nand3_1
X_07948_ _01892_ _01898_ _01899_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__nand3_1
XFILLER_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07879_ net344 net513 net505 net437 VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__a22o_1
XFILLER_28_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09618_ _03722_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__inv_2
X_09549_ net367 net543 _03645_ _03647_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_100_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10324_ _04487_ _04488_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__xnor2_1
XFILLER_3_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10255_ _04323_ _04325_ _04322_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_111_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10186_ _04267_ _04270_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__nand2_1
XFILLER_66_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout290 net296 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_2
XFILLER_74_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08920_ _02957_ _02959_ _02944_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__o21a_1
X_08851_ _02864_ _02882_ _02885_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__nand3_2
X_07802_ _01718_ _01740_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__xnor2_1
X_08782_ _02809_ _02810_ _02801_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__a21o_1
X_05994_ _05034_ _05036_ _05035_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__o21bai_1
XFILLER_29_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07733_ _01498_ _01501_ net158 _01665_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__a211oi_2
XFILLER_38_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07664_ net182 net395 net382 net222 VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__a22o_1
X_06615_ _00444_ _00447_ VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__xnor2_1
XFILLER_53_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09403_ _03366_ _03368_ _03487_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__o211ai_2
X_07595_ _01353_ _01357_ _01514_ _01515_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__o211a_1
X_06546_ _00286_ _00289_ _00371_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__o21ba_1
X_09334_ _03410_ _03411_ _03412_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__a21o_1
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06477_ net432 net469 net388 net191 VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_23_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09265_ _03337_ _03336_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__and2b_1
X_08216_ _02190_ _02191_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__xnor2_1
X_09196_ _02990_ _03260_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__nand2_1
X_05428_ _01573_ _01584_ _01181_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__a21o_1
XFILLER_21_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08147_ net171 net369 _02115_ _02116_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__nand4_1
X_05359_ net439 net629 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__and2_1
X_08078_ _02042_ _00771_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__nand2b_2
X_07029_ _00747_ _00749_ _00897_ _00899_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__o211a_2
XFILLER_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10040_ _04085_ _04088_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__nand2_1
XFILLER_102_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_7 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10307_ _04394_ _04397_ _04393_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__o21ba_1
XFILLER_79_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10238_ net555 net283 VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nand2_1
XFILLER_39_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10169_ net577 net569 net276 net269 VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__and4_1
XFILLER_94_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06400_ _00106_ _00114_ _00113_ VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__a21bo_1
XFILLER_35_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07380_ _01266_ _01279_ _01280_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__nor3_1
XFILLER_50_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06331_ _00049_ _00149_ VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__nor2_1
X_06262_ _00080_ _00081_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__xnor2_1
X_09050_ _03084_ _03103_ _03104_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_20_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08001_ net407 net616 net601 net415 VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__a22o_1
X_06193_ _05302_ _00012_ _00013_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__nand3_2
XFILLER_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09952_ net573 net307 net292 net581 VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__a22o_1
XFILLER_103_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08903_ _02933_ _02943_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09883_ _03999_ _04009_ _04010_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__and3_1
X_08834_ net297 net220 net305 net293 VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__nand4_2
X_08765_ _02659_ _02791_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__xor2_1
X_07716_ _01644_ _01647_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__xnor2_1
X_05977_ net213 net551 net447 net204 VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_28_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08696_ net298 net308 net293 net383 VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_0_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07647_ net444 net332 net325 net451 VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__a22o_1
X_07578_ _01494_ _01495_ _01496_ VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__nand3_4
XFILLER_25_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06529_ _00351_ _00352_ _00226_ _00228_ VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__a211o_1
X_09317_ net413 net405 net525 net509 VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__and4_1
XFILLER_40_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09248_ _03303_ _03316_ _03318_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__nor3_1
XFILLER_107_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09179_ _03197_ _03198_ _03242_ _03243_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_5_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput66 net66 VGND VGND VPWR VPWR C[10] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR C[30] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR C[20] sky130_fd_sc_hd__buf_2
Xoutput99 net99 VGND VGND VPWR VPWR C[40] sky130_fd_sc_hd__buf_2
XFILLER_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10023_ _04099_ _04101_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__nand2_1
XFILLER_76_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06880_ _00733_ _00734_ _00736_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__a21o_1
X_05900_ net216 net550 VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__nand2_1
X_05831_ _04955_ _04962_ _04963_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__nand3_1
XFILLER_94_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08550_ _02403_ _02406_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__nand2_1
X_05762_ _04892_ _04893_ _04875_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__a21oi_1
X_07501_ net548 net470 net42 net43 VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__and4_1
X_08481_ _02480_ _02481_ _02472_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05693_ _04461_ _04472_ _03734_ _03755_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__a211oi_1
XFILLER_90_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07432_ _01171_ _01179_ _01178_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__a21bo_1
XFILLER_50_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07363_ _01260_ _01261_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09102_ net358 net350 net592 net584 VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_33_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07294_ _01184_ _01185_ _01165_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__a21oi_1
X_06314_ _00045_ _00134_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__xnor2_1
X_06245_ _00047_ _00050_ _00062_ _00063_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__a22oi_1
X_09033_ _02868_ _02871_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_107_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06176_ net230 net224 net180 net239 VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__a22oi_1
XFILLER_117_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09935_ _04064_ _04065_ net614 net261 VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_5_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09866_ _03990_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__xnor2_1
X_08817_ net466 net280 net272 net549 VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_116_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09797_ _03914_ _03916_ _03809_ _03812_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__o211ai_2
X_08748_ _02758_ _02771_ _02773_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__nor3_1
X_08679_ net450 net264 _02696_ _02698_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_14_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10641_ net507 net242 VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__nand2_1
XFILLER_22_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10572_ _04755_ _04756_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__nand2_1
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10006_ _04142_ _04143_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_108_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06030_ _05158_ _05159_ net628 net373 VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__and4bb_1
XFILLER_114_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07981_ net401 net161 _01788_ _01787_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__a31o_1
XFILLER_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06932_ _00639_ _00792_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09720_ _03831_ _03833_ _03714_ _03717_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__o211a_1
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06863_ net239 net232 net602 net595 VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__and4_1
XFILLER_55_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09651_ net329 net321 net576 net569 VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__and4_1
X_06794_ net498 net520 net333 net327 VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__and4_1
XFILLER_103_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08602_ _02598_ _02612_ _02614_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__nor3_1
XFILLER_67_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09582_ _03573_ _03574_ _03572_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_38_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05814_ _04941_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__nand2b_1
X_08533_ _02425_ _02462_ _02461_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__o21bai_1
X_05745_ net216 net452 VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__nand2_1
XFILLER_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08464_ _02425_ _02463_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05676_ _04266_ _04299_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__xnor2_1
X_08395_ _02384_ _02385_ _02387_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__or3_1
X_07415_ _01317_ _01318_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__and2b_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07346_ _01129_ _01131_ _01242_ _01243_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__o211a_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07277_ _01167_ _01168_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__nor2_1
X_09016_ net466 net385 net275 net267 VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__and4_1
XFILLER_117_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06228_ _05265_ _00048_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__nor2_1
X_06159_ _05202_ _05204_ _05286_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__nand3_1
XFILLER_2_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout631 net632 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__clkbuf_4
X_09918_ net360 net352 net529 net514 VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__nand4_1
Xfanout620 net623 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09849_ _03972_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__and2b_1
XFILLER_86_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10624_ _04787_ _04811_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__xnor2_1
X_10555_ net531 net250 VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__nand2_1
X_10486_ _04655_ _04664_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__xor2_1
XFILLER_108_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05530_ _02697_ _02708_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__xnor2_1
XFILLER_60_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05461_ _01889_ _01944_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__xor2_1
X_07200_ _01083_ _01084_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__or2_1
X_08180_ _02150_ _02152_ _01970_ _01972_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__o211a_1
X_05392_ _01137_ _01148_ _01192_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_43_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07131_ _01002_ _01008_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__xnor2_1
X_07062_ _00783_ _00785_ _00933_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_93_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06013_ _05056_ _05058_ _05142_ _05143_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__o211ai_4
XFILLER_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07964_ _01775_ _01777_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__nor2_1
X_06915_ net611 net318 _00645_ _00643_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__a31o_1
X_07895_ _01807_ _01841_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__nand3_1
X_09703_ _03698_ _03700_ _03814_ _03815_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__a211oi_4
XFILLER_95_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06846_ _00690_ _00698_ _00699_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__nand3_2
X_09634_ _03740_ _03736_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__and2b_1
XFILLER_55_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06777_ _00622_ _00623_ _00483_ _00486_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__a211o_1
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09565_ _03623_ _03626_ _03663_ _03664_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__nand4_2
X_08516_ _02257_ _02355_ _02354_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09496_ _03587_ _03588_ _03584_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__a21o_1
X_05728_ _04223_ _04244_ _04847_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__nor3_1
XFILLER_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08447_ net377 net615 net600 net393 VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__a22o_1
X_05659_ _03994_ _04114_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__xnor2_1
X_08378_ _02367_ _02368_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__nand2_1
XFILLER_23_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07329_ net490 net310 net295 net497 VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__a22oi_1
XFILLER_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10340_ _04506_ _04507_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nor2_1
X_10271_ _04431_ _04432_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__or2_1
Xfanout450 net451 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
Xfanout483 net28 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__clkbuf_2
Xfanout461 net462 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_2
XFILLER_59_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout472 net473 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout494 net495 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10607_ _04791_ _04792_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10538_ _04717_ _04718_ _04719_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__and3_1
XFILLER_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10469_ net555 net250 VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_75_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06700_ _00536_ _00539_ _00426_ _00430_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__o211a_1
XFILLER_65_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07680_ _01458_ _01460_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_48_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06631_ _00461_ _00463_ _00443_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__a21oi_2
XFILLER_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06562_ _00292_ _00294_ _00291_ VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__o21ba_1
XFILLER_80_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09350_ _03427_ _03429_ _03421_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__a21o_1
X_08301_ _02283_ _02284_ _02276_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__a21o_1
XFILLER_80_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05513_ _01867_ _01999_ _02501_ _02512_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__o211ai_1
X_09281_ _03350_ _03354_ _03355_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__nand3_2
XFILLER_33_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08232_ _02209_ _02210_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__xor2_1
X_06493_ net212 net203 net223 net180 VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__and4_1
XFILLER_60_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05444_ net479 net486 net234 net228 VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__and4_1
XFILLER_119_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08163_ net415 net407 net600 net593 VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__and4_1
X_05375_ _00984_ _00995_ _01006_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__a21o_1
XFILLER_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08094_ _02057_ _02058_ VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__xnor2_1
X_07114_ _00990_ _00989_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__and2b_1
XFILLER_118_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07045_ _00915_ _00916_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__xnor2_1
XFILLER_102_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08996_ net366 net586 _03042_ _03043_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__nand4_1
X_07947_ _01896_ _01897_ _01893_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__a21o_1
XFILLER_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07878_ net256 net526 VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__and2_1
XFILLER_28_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06829_ _00677_ _00679_ _00562_ _00564_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__o211a_1
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09617_ _03564_ _03608_ net133 _03721_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__a211oi_2
X_09548_ net375 net532 net525 net392 VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__a22o_1
XFILLER_43_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09479_ _03571_ _03569_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__and2b_1
XFILLER_34_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10323_ _04488_ _04487_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__nand2b_1
XFILLER_3_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10254_ _04412_ _04413_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_111_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10185_ _04231_ _04240_ _04234_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__a21o_1
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
XFILLER_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_2
XFILLER_74_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08850_ _02864_ _02882_ _02885_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__and3_1
X_07801_ _01735_ _01737_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08781_ _02801_ _02809_ _02810_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__nand3_1
X_05993_ _05121_ _05122_ _05120_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__o21ai_1
XFILLER_38_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07732_ _01662_ _01663_ _01643_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_88_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07663_ net222 net182 net395 net382 VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__nand4_1
XFILLER_53_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06614_ _00445_ _00446_ VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__nor2_1
XFILLER_53_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09402_ _03485_ _03486_ net152 _03325_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__a211o_1
X_07594_ _01403_ _01404_ _01512_ _01513_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__a2bb2o_1
X_09333_ net336 net584 VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__and2_1
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06545_ net631 net334 _00266_ _00265_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__a31oi_1
XFILLER_40_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06476_ net191 net432 net469 net388 VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__and4_1
XFILLER_21_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09264_ _03201_ _03204_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__nor2_1
X_08215_ _02191_ _02190_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__and2b_1
X_09195_ _03125_ _03126_ _03262_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__o21a_1
X_05427_ _01181_ _01573_ _01584_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__nand3_2
X_08146_ net171 net369 _02115_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__a22o_1
XFILLER_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05358_ _00724_ _00833_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__nor2_1
X_08077_ _01062_ _02036_ _02037_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__or3_1
X_07028_ _00831_ _00832_ _00895_ _00896_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_102_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08979_ net169 net313 VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__nand2_1
XFILLER_75_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_8 net27 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10306_ _04464_ _04469_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__xor2_1
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10237_ _04393_ _04394_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__nor2_1
XFILLER_79_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10168_ _04313_ _04318_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10099_ net583 net576 net276 net268 VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_58_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06330_ _00049_ _00149_ VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__and2_1
X_06261_ _00081_ _00080_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_20_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08000_ net415 net407 net616 net601 VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__and4_1
X_06192_ _05302_ _00012_ _00013_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__and3_1
XFILLER_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09951_ net581 net573 net307 net292 VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__nand4_2
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08902_ _02941_ _02942_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__and2b_1
X_09882_ _04007_ _04008_ _04000_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__a21o_1
XFILLER_111_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08833_ net220 net313 _02744_ _02743_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a31o_1
X_08764_ _02659_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__or2_1
X_05976_ net213 net204 net551 net447 VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__nand4_1
XFILLER_72_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07715_ _01645_ _01646_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08695_ net383 net298 net308 net293 VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_0_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07646_ net451 net444 net332 net325 VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__and4_1
XFILLER_80_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07577_ _01326_ _01335_ _01334_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__a21bo_1
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06528_ _00226_ net149 _00351_ _00352_ VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__o211ai_4
X_09316_ net424 net504 _03001_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__and3_1
X_09247_ _03313_ _03314_ _03315_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__a21oi_1
X_06459_ _00269_ _00277_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__nand2_1
XFILLER_119_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09178_ _03197_ _03198_ _03242_ _03243_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__and4bb_1
XFILLER_5_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08129_ _02096_ _02098_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__and2b_1
XFILLER_31_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput67 net67 VGND VGND VPWR VPWR C[11] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR C[31] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR C[21] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10022_ _04160_ _04161_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__or2_1
XFILLER_76_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05830_ _04959_ _04960_ _04961_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__a21o_1
XFILLER_94_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07500_ net444 net340 VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05761_ _04875_ _04892_ _04893_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__nand3_1
X_08480_ _02472_ _02480_ _02481_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__nand3_1
X_05692_ _03734_ _03755_ _04461_ _04472_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__o211a_1
XFILLER_90_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07431_ _01334_ _01335_ _01326_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__a21o_1
XFILLER_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07362_ _01261_ _01260_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__and2b_1
XFILLER_16_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06313_ _00132_ _00133_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__xnor2_1
X_09101_ _03158_ _03159_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_33_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07293_ _01165_ _01184_ _01185_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__nand3_1
X_06244_ _00047_ _00050_ _00062_ _00063_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__nand4_1
X_09032_ _02933_ _02942_ _02941_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_96_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06175_ net239 net230 net224 net180 VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__and4_1
XFILLER_117_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09934_ net614 net261 _04064_ _04065_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_5_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09865_ net163 net250 VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__and2_1
XFILLER_85_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08816_ net549 net466 net280 net272 VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__and4_1
XFILLER_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09796_ _03809_ _03812_ _03914_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__a211o_2
XFILLER_45_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08747_ _02768_ _02769_ _02770_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__a21oi_1
X_05959_ net473 net460 net190 net432 VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__nand4_1
XFILLER_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08678_ net547 net279 net271 net443 VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__a22oi_1
XFILLER_53_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07629_ _01547_ _01550_ _01552_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__nand3_1
XFILLER_81_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10640_ net259 net507 net248 net500 _04828_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__a41o_1
XFILLER_13_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10571_ _04717_ _04754_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__nand2_1
XFILLER_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10005_ net315 net560 VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__nand2_1
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07980_ _01765_ _01768_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__nand2_1
XFILLER_4_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06931_ _00639_ _00792_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__and2_1
XFILLER_101_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09650_ _03754_ _03756_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__xor2_1
X_06862_ _00707_ _00716_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__xnor2_1
X_08601_ _02608_ _02609_ _02611_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__a21oi_1
XFILLER_103_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06793_ _00630_ _00640_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__xnor2_1
X_09581_ _03680_ _03682_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_38_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05813_ _04944_ _04945_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__xnor2_1
X_08532_ _02398_ _02418_ _02417_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__a21bo_1
X_05744_ _04876_ _04877_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__nor2_1
X_08463_ _02461_ _02462_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__nor2_1
X_07414_ _01315_ _01316_ _01310_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_18_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05675_ _04277_ _04288_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__nor2_1
X_08394_ _02217_ _02219_ _02215_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__o21ba_1
X_07345_ _01219_ _01221_ _01240_ _01241_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__a22o_1
X_07276_ net227 net580 net574 net237 VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__a22oi_1
XFILLER_31_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06227_ net610 net357 VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__nand2_1
X_09015_ _03061_ _03063_ _02928_ _02969_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__o211a_1
XFILLER_117_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06158_ _05202_ _05204_ _05286_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__a21o_1
X_06089_ _05210_ _05217_ _05218_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__nand3_1
Xfanout610 net611 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__clkbuf_4
Xfanout621 net623 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__clkbuf_4
Xfanout632 net1 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__buf_2
X_09917_ net353 net513 VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__nand2_1
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09848_ _03969_ _03970_ _03971_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__a21o_1
XFILLER_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09779_ net177 net242 VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nand2_1
XFILLER_37_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10623_ _04809_ _04810_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__nor2_1
XFILLER_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10554_ _04734_ _04735_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10485_ _04662_ _04663_ VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_114_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05460_ _01889_ _01944_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__and2_1
X_05391_ _01137_ _01148_ _01192_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__and3_1
XFILLER_32_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07130_ _01002_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__nand2b_1
XFILLER_13_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07061_ _00783_ _00785_ _00933_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_93_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06012_ _05140_ _05141_ _05083_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__a21o_1
XFILLER_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07963_ _01871_ _01915_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__xnor2_1
XFILLER_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06914_ _00655_ _00657_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__nor2_1
X_07894_ _01839_ _01840_ _01662_ net635 VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__a211o_1
X_09702_ _03812_ _03813_ _03802_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__a21oi_2
XFILLER_95_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06845_ _00695_ _00696_ _00697_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__a21o_1
XFILLER_68_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09633_ _03510_ _03739_ _03737_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__a21oi_2
XFILLER_82_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09564_ _03660_ _03662_ _03551_ _03553_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__o211ai_2
X_06776_ _00483_ _00486_ _00622_ _00623_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__o211ai_2
X_08515_ _02423_ _02519_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09495_ _03584_ _03587_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__nand3_2
X_05727_ _04223_ _04244_ _04847_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__o21a_1
X_08446_ net393 net377 net615 net600 VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__nand4_1
XFILLER_11_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05658_ _04092_ _04103_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__nand2_1
X_08377_ _02367_ _02368_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__or2_1
X_07328_ net490 net497 net310 net295 VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__and4_1
XFILLER_109_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05589_ _03036_ _03352_ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__and2_1
XFILLER_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07259_ _01009_ _01011_ _01149_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__a21o_2
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10270_ _04359_ _04361_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__nor2_1
Xfanout440 net442 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_2
XFILLER_48_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout462 net463 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__buf_2
Xfanout484 net28 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__buf_2
Xfanout451 net456 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_2
Xfanout473 net29 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_2
Xfanout495 net26 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__buf_2
XFILLER_59_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10606_ _04791_ _04792_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_40_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10537_ _04668_ _04672_ _04716_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__or3_1
XFILLER_50_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10468_ _04642_ _04643_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__xnor2_1
XFILLER_89_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10399_ _04496_ _04499_ _04497_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__o21ba_1
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06630_ _00443_ _00461_ _00463_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_48_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06561_ net492 net372 _00273_ _00271_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__a31o_1
XFILLER_52_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08300_ _02276_ _02283_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__nand3_1
X_06492_ _00205_ _00207_ _00206_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__o21ba_1
X_05512_ _01867_ _01999_ _02501_ _02512_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__o211a_1
X_09280_ net177 net282 _03351_ _03353_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__nand4_2
X_08231_ _02035_ _02047_ _02034_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__a21bo_1
XFILLER_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05443_ _01725_ _01736_ _01747_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__a21o_1
XFILLER_33_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08162_ net402 net616 VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__nand2_1
X_05374_ _00984_ _00995_ _01006_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__nand3_1
XFILLER_119_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08093_ _02058_ _02057_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nand2b_1
X_07113_ _00839_ _00841_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__nor2_1
XFILLER_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07044_ _00765_ _00773_ _00764_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_10_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08995_ net366 net586 _03042_ _03043_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__a22o_1
X_07946_ _01893_ _01896_ _01897_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__nand3_1
XFILLER_102_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07877_ _01819_ _01822_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__xnor2_1
XFILLER_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06828_ _00562_ _00564_ _00677_ _00679_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__a211oi_2
X_09616_ _03667_ _03669_ _03716_ _03718_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__o22a_1
X_06759_ _00566_ _00602_ _00603_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__or3_2
XFILLER_55_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09547_ net392 net375 net532 net525 VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__nand4_1
XFILLER_43_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09478_ _03447_ _03451_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__nor2_1
X_08429_ net298 net220 net331 net324 VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__and4_1
XFILLER_8_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10322_ _04411_ _04413_ _04410_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__o21ba_1
XFILLER_3_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10253_ net577 net262 VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10184_ _04336_ _04337_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__xor2_1
XFILLER_78_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout281 net52 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout270 net53 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__buf_2
Xfanout292 net296 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_4
XFILLER_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07800_ _01735_ _01737_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__nand2_1
XFILLER_97_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08780_ _02805_ _02806_ _02808_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__a21o_1
XFILLER_84_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07731_ _01662_ _01663_ _01643_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__nor3b_1
XFILLER_57_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05992_ _05120_ _05121_ _05122_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__or3_1
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07662_ net402 net182 _01448_ _01447_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__a31o_1
XFILLER_25_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07593_ _01403_ _01404_ _01512_ _01513_ VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__or4bb_2
X_06613_ net230 net624 net617 net239 VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__a22oi_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09401_ net152 _03325_ _03485_ _03486_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__o211ai_4
X_06544_ _00369_ _00370_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__xnor2_1
XFILLER_53_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09332_ net350 net576 net569 net358 VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__a22o_1
XFILLER_33_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06475_ _00293_ _00294_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__xnor2_1
X_09263_ _03334_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__nor2_1
XFILLER_119_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08214_ _01956_ _02016_ _02015_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__a21oi_1
X_09194_ _03125_ _03126_ _02987_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__a21o_1
X_05426_ _01551_ _01562_ _01126_ _01203_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__a211o_1
XFILLER_21_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08145_ net377 net162 net622 net393 VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__a22o_1
XFILLER_21_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05357_ net254 net629 _00702_ _00713_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_99_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08076_ _02036_ _02038_ _02039_ _02040_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__o211a_1
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07027_ _00831_ _00832_ _00895_ _00896_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__or4bb_2
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08978_ _03023_ _03024_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__and2b_1
X_07929_ _01879_ _01877_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__nand2b_1
XFILLER_56_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_9 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10305_ _04467_ _04468_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__xor2_1
XFILLER_106_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10236_ net291 net539 net531 net306 VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_72_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10167_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__inv_2
XFILLER_66_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10098_ _04242_ _04243_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__nand2_1
XFILLER_81_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06260_ _05277_ _05279_ _05278_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_20_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06191_ _00009_ _00010_ _00011_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__a21o_1
XFILLER_7_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09950_ net314 net573 _03963_ _03961_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__a31o_1
X_08901_ _02937_ _02939_ _02940_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__a21o_1
X_09881_ _04000_ _04007_ _04008_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__nand3_2
XFILLER_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08832_ _02716_ _02720_ VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__nand2_1
XFILLER_111_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05975_ _05030_ _05032_ _05029_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__o21bai_1
X_08763_ _02788_ _02789_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__xor2_1
X_07714_ net226 net559 net541 net236 VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_28_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08694_ net298 net316 _02584_ _02583_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_0_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07645_ _01567_ _01568_ _01396_ _01399_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__o211a_1
XFILLER_53_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07576_ _01492_ _01493_ _01484_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__a21o_1
XFILLER_34_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06527_ _00311_ _00312_ _00348_ _00349_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__o22ai_2
X_09315_ _03270_ _03391_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__xnor2_1
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06458_ _00270_ _00275_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__xnor2_1
X_09246_ _03316_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__inv_2
X_05409_ _01376_ _01387_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__and2b_1
XFILLER_31_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06389_ _00205_ _00208_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__xnor2_1
X_09177_ _03240_ _03241_ _03199_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__a21o_1
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08128_ net383 net331 net324 net464 VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__a22o_1
X_08059_ _01744_ _01851_ _01850_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__a21boi_1
XFILLER_103_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput79 net79 VGND VGND VPWR VPWR C[22] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput68 net68 VGND VGND VPWR VPWR C[12] sky130_fd_sc_hd__buf_2
X_10021_ _04159_ _04158_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__and2b_1
XFILLER_103_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10219_ _04258_ _04261_ _04374_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__a211oi_2
X_05760_ _04875_ _04892_ _04893_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_85_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05691_ _04440_ _04451_ _04255_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__a21o_1
XFILLER_35_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07430_ _01326_ _01334_ _01335_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__nand3_1
XFILLER_23_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07361_ _01100_ _01102_ _01101_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__o21ba_1
X_06312_ _00022_ _00024_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__nand2b_1
X_09100_ net159 net312 VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__nand2_1
XFILLER_31_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07292_ _01165_ _01184_ _01185_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__and3_1
X_09031_ _03081_ _03082_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__xor2_1
X_06243_ _00047_ _00050_ _00062_ _00063_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06174_ net216 net300 VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__nand2_1
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09933_ net591 net276 net269 net599 VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_5_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09864_ _03987_ _03988_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__xnor2_1
X_08815_ _02737_ _02740_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__nor2_1
XFILLER_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09795_ _03912_ _03913_ _03902_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08746_ _02771_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__inv_2
X_05958_ _05087_ _05088_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__xnor2_1
X_08677_ net547 net443 net279 net271 VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__and4_1
X_05889_ net213 net204 net453 net447 VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__nand4_1
X_07628_ net489 net288 _01548_ _01549_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_52_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07559_ _01473_ _01474_ _01469_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10570_ _04717_ _04754_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__or2_1
XFILLER_21_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09229_ _03162_ _03163_ _03161_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__a21bo_1
XFILLER_5_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10004_ _04140_ _04141_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__and2b_1
XFILLER_76_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06930_ _00790_ _00791_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06861_ _00707_ _00716_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__nand2b_1
X_08600_ _02612_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__inv_2
X_06792_ _00630_ _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__nand2_1
XFILLER_82_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09580_ _03681_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_38_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05812_ net472 net196 VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__nand2_1
X_08531_ _02379_ _02422_ _02421_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__o21ai_1
X_05743_ net241 net550 net446 net231 VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__a22oi_1
X_08462_ _02458_ _02460_ _02316_ _02318_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__o211a_1
XFILLER_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05674_ net229 net452 net446 net58 VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__a22oi_1
X_07413_ _01310_ _01315_ _01316_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__and3_1
XFILLER_50_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08393_ _02384_ _02385_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__nor2_1
X_07344_ _01219_ _01221_ _01240_ _01241_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_75_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07275_ net237 net227 net580 net574 VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__and4_1
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06226_ net610 net365 net357 net631 VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__a22o_1
X_09014_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__inv_2
XFILLER_117_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06157_ _05276_ _05284_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__xnor2_1
X_06088_ _05214_ _05215_ _05216_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__a21o_1
Xfanout611 net12 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__clkbuf_2
Xfanout622 net623 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__clkbuf_2
Xfanout600 net601 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__buf_2
X_09916_ _04044_ _04045_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__xnor2_1
XFILLER_58_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09847_ _03969_ _03970_ _03971_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__and3_1
XFILLER_46_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09778_ _03894_ _03895_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08729_ _02590_ _02591_ _02589_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__a21bo_1
XFILLER_42_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10622_ _04807_ _04808_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__and2_1
XFILLER_10_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10553_ _04735_ _04734_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__and2b_1
XFILLER_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10484_ _04592_ _04596_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__nor2_1
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05390_ _01159_ _01170_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_43_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07060_ _00780_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__xnor2_1
XFILLER_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06011_ _05083_ _05140_ _05141_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__nand3_2
XFILLER_114_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07962_ _01915_ _01871_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__nand2b_1
X_09701_ _03802_ _03812_ _03813_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__and3_2
X_06913_ _00765_ _00773_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__xor2_1
X_07893_ _01662_ net635 _01839_ _01840_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__o211ai_2
XFILLER_95_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06844_ _00695_ _00696_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__nand3_2
XFILLER_68_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09632_ _03738_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__inv_2
X_09563_ _03551_ _03553_ _03660_ _03662_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__a211o_1
X_06775_ _00619_ _00620_ _00372_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__a21o_1
X_08514_ _02516_ _02517_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09494_ net160 net282 _03585_ _03586_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__nand4_2
XFILLER_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05726_ _04741_ _04826_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__xnor2_1
X_08445_ net402 net600 _02301_ _02300_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__a31o_1
XFILLER_51_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05657_ net628 net420 _04081_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__a21o_1
X_08376_ _02048_ _02203_ _02202_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_83_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05588_ _03330_ _03341_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__xnor2_1
X_07327_ _01095_ _01097_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__nor2_1
XFILLER_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07258_ _01138_ _01146_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__xnor2_1
X_07189_ _01069_ _01070_ net609 net288 VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__and4bb_1
X_06209_ _00029_ _00030_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__nor2_1
XFILLER_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_92_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout441 net442 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout430 net34 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_4
Xfanout463 net30 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__buf_4
Xfanout474 net478 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__buf_2
Xfanout452 net453 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__buf_2
Xfanout485 net28 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__buf_2
Xfanout496 net497 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__buf_2
XFILLER_59_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10605_ _04740_ _04744_ _04742_ VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_12_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10536_ _04672_ _04716_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__nand2_1
XFILLER_115_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10467_ _04643_ _04642_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nand2b_1
XFILLER_89_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10398_ _04567_ _04568_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06560_ _00376_ _00377_ _00384_ _00386_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__a22o_1
XFILLER_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06491_ _00197_ _00199_ _00196_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__o21ba_1
XFILLER_60_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05511_ _02479_ _02490_ _02293_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__a21o_1
X_08230_ _02207_ _02208_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__nor2_1
X_05442_ _01725_ _01736_ _01747_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__nand3_1
X_08161_ _01981_ _01989_ _01987_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__a21o_1
X_05373_ _00309_ _00320_ _00298_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__a21bo_1
XFILLER_119_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08092_ _01874_ _01876_ _01873_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__o21ba_1
X_07112_ _00985_ _00988_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__xnor2_1
X_07043_ _00912_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__nor2_1
XFILLER_114_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08994_ net374 net579 net572 net391 VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__a22o_1
X_07945_ net474 net287 _01894_ _01895_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__nand4_1
X_07876_ _01820_ _01821_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__nor2_1
XFILLER_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09615_ _03667_ _03669_ _03716_ _03718_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__or4_1
X_06827_ _00674_ _00676_ _00660_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__o21a_1
XFILLER_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06758_ _00566_ _00602_ _00603_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__nor3_1
XFILLER_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09546_ net400 net525 _03512_ _03511_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__a31o_1
XFILLER_70_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05709_ _04645_ _04656_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__nand2b_1
X_09477_ _03567_ _03568_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nor2_1
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06689_ _00525_ _00526_ _00521_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__a21o_1
X_08428_ _02288_ _02290_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__and2b_1
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08359_ _02347_ _02349_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__nor2_1
XFILLER_119_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10321_ _04485_ _04486_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__xnor2_1
X_10252_ _04410_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nor2_1
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10183_ net599 net243 VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__nand2_1
XFILLER_94_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_2
XFILLER_47_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout282 net285 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
Xfanout260 net54 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_2
XFILLER_115_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout293 net295 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_4
XFILLER_62_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10519_ _04696_ _04697_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__nand2_1
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07730_ _01658_ _01659_ _01661_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__a21oi_1
X_05991_ net346 net183 net175 net439 VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__a22oi_2
XFILLER_38_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07661_ _01425_ _01428_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_88_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07592_ _01510_ _01511_ _01349_ _01351_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__a211o_1
X_06612_ net239 net232 net624 net617 VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__and4_1
XFILLER_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09400_ _03482_ _03484_ _03464_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__a21o_1
X_06543_ _00247_ _00255_ VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__nor2_1
X_09331_ net358 net350 net576 net569 VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__nand4_1
XFILLER_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06474_ net461 net404 VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__nand2_1
XFILLER_33_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09262_ _03332_ _03333_ net385 net260 VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__and4bb_1
X_09193_ _02991_ _03260_ VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__nand2_1
X_08213_ _02133_ _02189_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__xor2_1
X_05425_ _01126_ _01203_ _01551_ _01562_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__o211ai_4
XFILLER_21_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08144_ net393 net377 net162 net622 VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__nand4_1
X_05356_ _00768_ _00811_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__nor2_1
XFILLER_119_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08075_ _01691_ _01863_ _01864_ VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__a21boi_1
XFILLER_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07026_ net634 _00894_ _00742_ _00744_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08977_ net620 net329 net321 net160 VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__a22o_1
X_07928_ _01702_ _01705_ _01701_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__o21ba_1
XFILLER_56_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07859_ _01800_ _01801_ _01785_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__a21o_1
XFILLER_56_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09529_ net406 net400 net509 net504 VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__nand4_2
XFILLER_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10304_ net283 net539 VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__nand2_1
X_10235_ net306 net291 net539 net531 VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_72_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10166_ _04316_ _04317_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10097_ _04155_ _04241_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__nand2_1
XFILLER_19_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06190_ _00009_ _00010_ _00011_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__nand3_4
XFILLER_116_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08900_ _02937_ _02939_ _02940_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__and3_1
X_09880_ _04004_ _04006_ _04001_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__a21o_1
XFILLER_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08831_ _02747_ _02756_ _02755_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__a21o_1
XFILLER_58_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08762_ _02789_ _02788_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__and2b_1
X_05974_ _05021_ _05024_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__nand2_1
X_08693_ _02560_ _02563_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__nand2_1
X_07713_ net236 net226 net557 net541 VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__and4_1
XFILLER_38_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07644_ _01396_ _01399_ _01567_ _01568_ VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__a211oi_1
XFILLER_93_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07575_ _01484_ _01492_ _01493_ VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__nand3_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06526_ _00311_ _00312_ _00348_ _00349_ VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__or4_2
XFILLER_34_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09314_ _03391_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__inv_2
X_06457_ _00270_ _00275_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__nand2b_1
X_09245_ _03313_ _03314_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__and3_1
X_05408_ net486 net234 net228 net493 VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__a22o_1
X_06388_ _00206_ _00207_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__nor2_1
X_09176_ _03199_ _03240_ _03241_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__nand3_1
X_08127_ net464 net383 net331 net324 VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__and4_1
X_05339_ _00484_ _00495_ _00626_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__and3_1
X_08058_ _01917_ _02020_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__xnor2_1
X_07009_ _00874_ _00875_ _00873_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__a21o_1
XFILLER_103_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput69 net69 VGND VGND VPWR VPWR C[13] sky130_fd_sc_hd__buf_2
X_10020_ _04158_ _04159_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__and2b_1
XFILLER_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10218_ _04372_ _04373_ _04293_ _04295_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__o211a_1
XFILLER_67_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10149_ _04300_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_85_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05690_ _04255_ _04440_ _04451_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__nand3_1
XFILLER_35_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07360_ _01255_ _01259_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06311_ _00130_ _00131_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07291_ _01180_ _01182_ _01183_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__a21o_1
X_09030_ _03081_ _03082_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__or2_1
XFILLER_30_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06242_ _05259_ _05261_ _00061_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_96_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06173_ _05292_ _05300_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09932_ net599 net591 net276 net269 VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__and4_1
XFILLER_97_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09863_ _03988_ _03987_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__and2b_1
XFILLER_112_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08814_ _02845_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__inv_2
XFILLER_85_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09794_ _03902_ _03912_ _03913_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__nand3_1
X_08745_ _02768_ _02769_ _02770_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__and3_1
X_05957_ net518 net404 VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__nand2_1
X_08676_ _02538_ _02581_ _02580_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__a21o_1
XFILLER_66_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05888_ _04952_ _04954_ _04951_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__o21bai_1
XFILLER_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07627_ net490 net288 _01548_ _01549_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_52_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07558_ _01469_ _01473_ _01474_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__and3_1
X_06509_ net348 net603 net595 net441 VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__a22oi_2
X_07489_ _01395_ _01397_ _01378_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09228_ _03293_ _03294_ _03295_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__nand3_1
XFILLER_5_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09159_ net219 net282 _03221_ _03223_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__a22o_1
XFILLER_107_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10003_ net323 net545 net537 net330 VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__a22o_1
XFILLER_29_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_103_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_112_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06860_ _00708_ _00714_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__xnor2_1
X_05811_ _04942_ _04943_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__nor2_1
X_06791_ _00497_ _00638_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_38_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08530_ net489 net246 _02396_ _02395_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__a31o_1
X_05742_ net241 net231 net550 net446 VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__and4_1
X_08461_ _02316_ _02318_ _02458_ _02460_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__a211oi_1
XFILLER_63_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05673_ net235 net229 net452 net446 VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__and4_1
X_07412_ _01313_ _01314_ _01312_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_18_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08392_ _02382_ _02383_ net474 net263 VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__and4bb_1
XFILLER_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07343_ _01238_ _01239_ _01079_ _01081_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__a211o_1
XFILLER_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07274_ net215 net587 VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__nand2_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06225_ _05262_ _05263_ _05266_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__o21ba_1
X_09013_ _02928_ _02969_ net142 _03063_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__a211oi_2
XFILLER_117_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06156_ _05276_ _05284_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__and2_1
XFILLER_104_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06087_ _05214_ _05215_ _05216_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__nand3_1
Xfanout623 net10 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__buf_2
Xfanout601 net13 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__buf_2
X_09915_ net314 net566 VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__nand2_1
Xfanout612 net614 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__buf_2
XFILLER_86_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09846_ _03865_ _03868_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_107_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06989_ _00710_ _00712_ _00709_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__o21ba_1
XFILLER_58_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09777_ _03894_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__or2_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08728_ _02748_ _02749_ _02750_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__nand3_1
XFILLER_39_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08659_ _02674_ _02675_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__nand2_1
XFILLER_53_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10621_ _04807_ _04808_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__nor2_1
XFILLER_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10552_ _04690_ _04692_ _04689_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__o21ba_1
XFILLER_6_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10483_ _04657_ _04660_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__xor2_2
XFILLER_6_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06010_ _05138_ _05139_ _05050_ _05053_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_93_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07961_ _01872_ _01913_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__xor2_1
XFILLER_114_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06912_ _00253_ _00766_ _00771_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__a21oi_2
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09700_ _03809_ _03811_ _03803_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a21o_1
XFILLER_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07892_ _01837_ _01838_ _01818_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__a21o_1
X_06843_ _00552_ _00553_ _00551_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__o21bai_1
XFILLER_67_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09631_ _03508_ _03621_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__nand2_1
X_06774_ _00372_ _00619_ _00620_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__nand3_1
XFILLER_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09562_ _03658_ _03659_ _03518_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__a21oi_1
X_08513_ _02517_ _02516_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__and2b_1
XFILLER_82_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05725_ _04741_ _04826_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__nand2b_1
X_09493_ net160 net282 _03585_ _03586_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_102_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08444_ _02278_ _02281_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__nand2_1
XFILLER_51_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05656_ net627 net420 _04081_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__nand3_2
X_08375_ _02211_ _02365_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__xnor2_1
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05587_ net627 net425 VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__nand2_1
X_07326_ _01069_ _01073_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__nor2_1
X_07257_ _01138_ _01146_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__and2_1
X_07188_ net609 net288 _01069_ _01070_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__o2bb2a_1
X_06208_ _00027_ _00028_ _05249_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__o21a_1
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06139_ _05267_ _05251_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_113_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout431 net434 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_2
Xfanout420 net421 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__buf_2
Xfanout475 net478 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_2
Xfanout464 net465 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_4
Xfanout453 net456 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__buf_2
XFILLER_59_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout442 net33 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_2
Xfanout497 net26 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__buf_2
X_09829_ net368 net505 VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__nand2_1
XFILLER_74_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10604_ _04789_ _04790_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_12_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10535_ _04668_ _04716_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__nand2_1
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10466_ _04601_ _04604_ _04600_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__o21ba_1
XFILLER_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10397_ _04567_ _04568_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_75_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06490_ _00307_ _00310_ _00185_ _00187_ VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__a211oi_2
X_05510_ _02293_ _02479_ _02490_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nand3_2
X_05441_ _01300_ _01311_ _01289_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__o21bai_1
X_08160_ _02095_ _02132_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__xor2_1
XFILLER_60_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07111_ _00986_ _00987_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nor2_1
XFILLER_20_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05372_ _00951_ _00962_ _00973_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__o21ai_1
X_08091_ _02055_ _02056_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__xnor2_1
X_07042_ _00761_ _00910_ _00911_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__and3_1
XFILLER_114_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ net391 net374 net579 net572 VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__nand4_1
X_07944_ net474 net287 _01894_ _01895_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__a22o_1
XFILLER_87_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07875_ net226 net541 net533 net236 VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__a22oi_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06826_ _00660_ _00674_ _00676_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__or3_1
XFILLER_68_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09614_ _03667_ _03669_ _03716_ _03718_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__nor4_1
X_06757_ _00599_ _00601_ _00461_ _00465_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__o211a_1
XFILLER_71_638 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09545_ _03540_ _03543_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__nand2_1
X_06688_ _00521_ _00525_ _00526_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__nand3_1
XFILLER_70_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05708_ _04624_ _04635_ _03930_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__a21o_1
X_09476_ _03565_ _03566_ net219 net258 VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__and4bb_1
XFILLER_34_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08427_ _02379_ _02422_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__xor2_1
X_05639_ _02599_ _03167_ _03156_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__a21bo_1
X_08358_ _02155_ _02185_ _02183_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__a21oi_1
XFILLER_109_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07309_ _01201_ _01202_ _01045_ _01047_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__a211oi_1
X_08289_ _02268_ _02269_ _02270_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__a21o_1
X_10320_ net570 net262 VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__nand2_1
XFILLER_118_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10251_ net562 net277 net268 net570 VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__a22oi_1
XFILLER_78_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10182_ _04333_ _04334_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__xnor2_1
Xfanout250 net253 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_2
Xfanout272 net273 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_2
Xfanout261 net262 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_2
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_2
XFILLER_101_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10518_ _04696_ _04697_ VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__or2_1
X_10449_ _04560_ _04561_ _04563_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__o21bai_2
XFILLER_69_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05990_ net439 net346 net183 net175 VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__and4_1
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07660_ _01576_ _01586_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_88_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07591_ _01349_ _01351_ _01510_ _01511_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__o211ai_2
XFILLER_65_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06611_ net218 net164 VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__nand2_1
XFILLER_53_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06542_ _00245_ _00368_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__xor2_1
X_09330_ _03407_ _03408_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09261_ net385 net260 _03332_ _03333_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__o2bb2a_1
X_06473_ _00291_ _00292_ VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__nor2_1
X_08212_ _02186_ _02187_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__xor2_1
XFILLER_21_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09192_ _02989_ _03127_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__nor2_1
X_05424_ _01464_ _01475_ _01540_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__a21o_1
XFILLER_119_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08143_ net402 net622 _01959_ _01958_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__a31o_1
X_05355_ net235 net629 _00757_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08074_ _01692_ _01695_ _01865_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_99_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07025_ _00742_ _00744_ net634 _00894_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__a211o_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08976_ net160 net620 net329 net321 VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__and4_1
X_07927_ _01875_ _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07858_ _01785_ _01800_ _01801_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__nand3_1
X_07789_ _01721_ _01724_ _01726_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__nand3_1
X_06809_ _00657_ _00659_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__or2_1
XFILLER_56_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09528_ net399 net504 VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__nand2_1
XFILLER_37_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09459_ _03546_ _03547_ _03549_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__and3_1
XFILLER_8_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10303_ _04465_ _04466_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__nand2_1
XFILLER_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10234_ _04315_ _04317_ _04314_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_72_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10165_ net314 net537 VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__nand2_1
XFILLER_86_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10096_ _04155_ _04241_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__or2_1
XFILLER_74_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08830_ _02860_ _02862_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__xor2_1
XFILLER_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08761_ _02649_ _02653_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__and2_1
X_05973_ _05102_ _05103_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__nand2_1
X_08692_ _02587_ _02596_ _02595_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__a21o_1
X_07712_ net214 net568 VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__nand2_1
X_07643_ _01565_ _01566_ _01440_ _01443_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__a211oi_1
XFILLER_93_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07574_ _01489_ _01490_ _01491_ VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__a21o_1
X_09313_ _03389_ _03390_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__and2b_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06525_ _00311_ _00312_ _00348_ _00349_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__nor4_1
XFILLER_80_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06456_ _00273_ _00274_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__xnor2_1
X_09244_ _03172_ _03180_ _03179_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__a21bo_1
X_09175_ _03238_ _03239_ _03056_ _03059_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__a211o_1
X_05407_ net486 net493 net234 net228 VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__and4_1
XFILLER_119_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08126_ _01948_ _01950_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__nor2_1
X_06387_ net230 net172 net164 net240 VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__a22oi_1
X_05338_ _00593_ _00604_ _00571_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__a21o_1
X_08057_ _02017_ _02018_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07008_ _00873_ _00874_ _00875_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__nand3_1
XFILLER_0_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08959_ net424 net534 VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_27_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10217_ _04293_ _04295_ _04372_ _04373_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__a211oi_2
XFILLER_79_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10148_ _04174_ _04175_ _04178_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__o21a_1
X_10079_ _04221_ _04224_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__nor2_1
XFILLER_63_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06310_ _00069_ _00070_ _00128_ _00129_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__a2bb2o_1
X_07290_ _01180_ _01182_ _01183_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__nand3_2
XFILLER_15_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06241_ _05259_ _05261_ _00061_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__a21o_1
XFILLER_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06172_ _05292_ _05300_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__nand2b_1
XFILLER_116_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09931_ _04015_ _04018_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__nand2_1
XFILLER_58_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09862_ _03884_ _03888_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__nor2_1
XFILLER_97_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08813_ _02706_ _02707_ _02711_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__o21ai_1
X_09793_ _03902_ _03912_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__and3_1
XFILLER_100_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08744_ _02600_ _02607_ _02606_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__a21bo_1
X_05956_ _05085_ _05086_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__and2b_1
XFILLER_38_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08675_ net482 net246 _02553_ _02552_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__a31o_1
X_05887_ net472 net196 _04944_ _04942_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__a31o_1
X_07626_ net475 net308 net293 net483 VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_52_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07557_ _01471_ _01472_ _01470_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__a21bo_1
XFILLER_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06508_ net441 net348 net603 net595 VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__and4_1
XFILLER_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07488_ _01378_ _01395_ _01397_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__or3_2
XFILLER_21_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06439_ _00256_ _00257_ VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__and2_1
XFILLER_21_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09227_ _03293_ _03294_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__a21o_1
XFILLER_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09158_ net169 net304 net289 net176 VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__a22o_1
X_08109_ net457 net287 _02073_ _02074_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__nand4_2
X_09089_ _02648_ _02895_ _03143_ _03146_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__or4b_2
XFILLER_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10002_ net330 net323 net544 net536 VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__and4_1
XFILLER_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05810_ net460 net204 net453 net213 VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__a22oi_1
X_06790_ _00497_ _00638_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__and2b_1
XFILLER_94_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05741_ _04865_ _04873_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_38_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08460_ _02454_ _02456_ _02441_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__o21a_1
XFILLER_51_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05672_ net217 net459 VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__nand2_1
X_08391_ net474 net263 _02382_ _02383_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__o2bb2a_1
X_07411_ _01312_ _01313_ _01314_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_18_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07342_ _01079_ _01081_ _01238_ _01239_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__o211ai_4
X_07273_ _01154_ _01163_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__xnor2_1
X_06224_ _05250_ _05269_ _05268_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__a21o_1
X_09012_ _03020_ _03021_ _03059_ _03060_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__o22a_1
X_06155_ _05281_ _05282_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__xor2_1
XFILLER_105_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06086_ _05120_ _05122_ _05121_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__o21bai_1
XFILLER_104_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout624 net625 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__buf_2
Xfanout602 net603 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__buf_2
X_09914_ _04042_ _04043_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__and2b_1
Xfanout613 net614 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_2
XFILLER_112_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09845_ net337 net544 _03967_ _03968_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__nand4_1
XFILLER_112_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_107_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06988_ _00850_ _00852_ _00698_ _00700_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__o211a_1
X_09776_ _03793_ _03794_ _03792_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__a21oi_1
XFILLER_27_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08727_ _02748_ _02749_ _02750_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__a21o_1
X_05939_ _04988_ _05067_ _05069_ _04991_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__a22oi_4
X_08658_ _02674_ _02675_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__nor2_1
X_07609_ net497 net281 net273 net519 VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__a22oi_1
XFILLER_81_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08589_ net401 net593 _02470_ _02469_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__a31o_1
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10620_ net523 net242 VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__nand2_1
X_10551_ _04732_ _04733_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_118_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10482_ _04657_ _04660_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__nand2_1
XFILLER_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07960_ _01913_ _01872_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__nand2b_1
XFILLER_87_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06911_ _00041_ _00250_ _00766_ VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__and3_1
X_07891_ _01818_ _01837_ _01838_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__nand3_1
XFILLER_83_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06842_ _00692_ _00693_ _00694_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__a21bo_1
X_09630_ _03506_ _03620_ _03619_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__o21ba_1
X_06773_ _00372_ _00619_ _00620_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__and3_1
X_09561_ _03518_ _03658_ _03659_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__nand3_1
XFILLER_36_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08512_ _02296_ _02351_ _02350_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__a21oi_1
X_05724_ _04795_ _04805_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09492_ net612 net304 net289 net619 VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_102_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08443_ _02430_ _02440_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__xnor2_1
XFILLER_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05655_ _04048_ _04059_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__xnor2_1
X_08374_ _02211_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__nand2_1
X_05586_ _03308_ _03319_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__nor2_1
X_07325_ net609 net632 net281 net273 VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__nand4_1
XFILLER_109_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07256_ _01143_ _01144_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__xnor2_1
X_06207_ _05249_ _00027_ _00028_ VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__nor3_1
X_07187_ net498 net311 net295 net519 VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__a22oi_1
X_06138_ _05264_ _05265_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__xor2_1
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06069_ net203 net551 net468 net211 VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__a22oi_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout410 net412 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__buf_2
Xfanout432 net434 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_2
Xfanout421 net36 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__clkbuf_4
Xfanout465 net466 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__buf_2
Xfanout443 net444 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__clkbuf_4
Xfanout454 net455 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_2
Xfanout498 net499 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__buf_2
Xfanout476 net478 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__buf_2
XFILLER_74_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09828_ net368 net513 net505 net376 VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__a22o_1
Xfanout487 net488 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__buf_2
XFILLER_104_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09759_ _03858_ _03874_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10603_ _04714_ _04753_ _04788_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_12_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10534_ _04714_ _04715_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__nor2_1
XFILLER_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10465_ _04640_ _04641_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__xnor2_1
XFILLER_89_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10396_ _04434_ _04436_ _04508_ VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__o21ai_1
XFILLER_111_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05440_ _01703_ _01714_ _01693_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__o21ai_1
X_05371_ _00951_ _00962_ _00973_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__or3_1
XFILLER_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07110_ net429 net173 net165 net187 VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__a22oi_1
XFILLER_13_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08090_ net489 net263 VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__nand2_1
X_07041_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__inv_2
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08992_ net400 net572 _02903_ _02902_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__a31o_1
X_07943_ net450 net309 net294 net457 VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__a22o_1
X_07874_ net236 net226 net541 net533 VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__and4_1
XFILLER_95_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06825_ _00660_ _00674_ _00676_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__nor3_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09613_ _03714_ _03715_ _03671_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__a21oi_1
XFILLER_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06756_ _00461_ _00465_ _00599_ _00601_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__a211oi_4
X_09544_ _03631_ _03641_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__xnor2_1
X_06687_ _00522_ _00523_ _00524_ VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__a21bo_1
XFILLER_64_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05707_ _03930_ _04624_ _04635_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__and3_1
X_09475_ net219 net258 _03565_ _03566_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08426_ _02381_ _02420_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__xor2_1
X_05638_ _03864_ _03875_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__xnor2_1
X_08357_ _02320_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__xnor2_1
X_05569_ _03113_ _03124_ _02151_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__a21oi_1
XFILLER_109_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07308_ _01045_ _01047_ _01201_ _01202_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__o211a_1
X_08288_ _02268_ _02269_ _02270_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_115_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07239_ _01124_ _01125_ _01111_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__a21bo_1
XFILLER_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10250_ net569 net562 net276 net268 VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__and4_1
XFILLER_117_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10181_ _04333_ _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__or2_1
XFILLER_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout240 net241 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_1
Xfanout273 net53 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_4
Xfanout251 net252 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout262 net54 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_2
Xfanout295 net296 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10517_ net539 net250 VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__and2_1
XFILLER_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10448_ _04622_ _04623_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__nor2_1
X_10379_ net570 net249 VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__and2_1
XFILLER_111_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07590_ _01443_ _01444_ _01507_ _01509_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_92_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06610_ _00432_ _00442_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__xor2_2
XFILLER_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06541_ _00242_ _00366_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__xnor2_1
X_06472_ net449 net419 net411 net455 VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__a22oi_1
X_09260_ net219 net275 net267 net297 VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__a22oi_1
X_08211_ _02186_ _02187_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__nor2_1
X_05423_ _01464_ _01475_ _01540_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__nand3_2
XFILLER_21_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09191_ _03257_ _03258_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__or2_1
X_08142_ _01938_ _01941_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__nand2_1
X_05354_ _00778_ _00789_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__and2_1
X_08073_ _01060_ _02037_ _01216_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_99_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07024_ _00853_ _00855_ _00891_ _00892_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__o22a_1
XFILLER_115_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08975_ _03021_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__inv_2
X_07926_ net496 net263 VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__nand2_1
XFILLER_29_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07857_ _01798_ _01799_ _01790_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__a21o_1
X_07788_ net483 net286 _01722_ _01723_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__nand4_1
X_06808_ _00655_ _00656_ _00648_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__o21ba_1
XFILLER_56_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06739_ _00579_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__xnor2_1
X_09527_ net399 net509 net504 net405 VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__a22o_1
XFILLER_43_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09458_ _03421_ _03429_ _03427_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__a21bo_1
X_08409_ net464 net308 net293 net547 VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__a22o_1
XFILLER_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09389_ _03470_ _03471_ _03467_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_22_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10302_ net291 net538 net524 net307 VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__a22o_1
XFILLER_3_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10233_ _04343_ _04346_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_72_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10164_ _04314_ _04315_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__nor2_1
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10095_ _04235_ _04240_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__xnor2_1
XFILLER_47_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05972_ _05100_ _05101_ _05011_ _05013_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__a211o_1
X_08760_ _02786_ _02787_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__xor2_1
XFILLER_93_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08691_ _02709_ _02710_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__xor2_1
X_07711_ _01632_ _01642_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__xor2_1
XFILLER_65_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07642_ _01440_ _01443_ _01565_ _01566_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__o211a_1
XFILLER_93_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07573_ _01489_ _01490_ _01491_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__nand3_1
X_09312_ _03386_ _03388_ _03252_ _03254_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__o211ai_1
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06524_ _00345_ _00347_ _00221_ _00224_ VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__o211a_1
XFILLER_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06455_ net492 net372 VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__nand2_1
XFILLER_21_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09243_ _03311_ _03312_ _03304_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__a21o_1
XFILLER_119_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06386_ net240 net230 net172 net164 VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__and4_1
X_09174_ _03056_ _03059_ _03238_ _03239_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__o211ai_2
X_05406_ _01322_ _01333_ _01344_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__a21o_1
XFILLER_31_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08125_ _02050_ _02093_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__xor2_1
X_05337_ _00571_ _00604_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__nand2b_1
X_08056_ _02018_ _02017_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__and2b_1
X_07007_ net348 net573 net567 net437 VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__a22o_1
XFILLER_1_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08958_ net430 net526 net510 net188 VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__a22o_1
X_07909_ _01683_ _01686_ _01856_ _01858_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__o211ai_1
X_08889_ net170 net161 net329 net321 VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__and4_1
XFILLER_29_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10216_ _04370_ _04371_ _04285_ _04289_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__o211a_1
XFILLER_79_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10147_ _04295_ _04296_ _04211_ _04214_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__a211o_1
XFILLER_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10078_ _04118_ _04121_ _04220_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_85_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06240_ _00051_ _00059_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__xnor2_1
X_06171_ _05293_ _05298_ VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09930_ _04058_ _04060_ _03959_ _03978_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09861_ _03985_ _03986_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__nor2_1
X_08812_ _02843_ _02844_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__xor2_1
XFILLER_58_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09792_ _03910_ _03911_ _03903_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__a21o_1
XFILLER_100_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08743_ _02766_ _02767_ _02759_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__a21o_1
X_05955_ net488 net420 net412 net495 VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__a22o_1
XFILLER_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08674_ _02689_ _02693_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__xor2_1
XFILLER_26_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05886_ _05015_ _05016_ _04932_ _04934_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__a211o_1
X_07625_ net483 net475 net308 net293 VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_52_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07556_ _01470_ _01471_ _01472_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_52_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06507_ net255 net617 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__nand2_1
X_07487_ _01393_ _01394_ _01236_ _01238_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__o211a_1
X_09226_ net336 net590 VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__and2_1
X_06438_ _00150_ _00170_ _00172_ VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__or3_1
XFILLER_21_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06369_ _00098_ _00100_ _00188_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__a21o_2
X_09157_ net176 net169 net304 net289 VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__nand4_2
X_08108_ net457 net287 _02073_ _02074_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__a22o_1
X_09088_ _03141_ _03142_ _03135_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__o21bai_1
XFILLER_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08039_ _01825_ _01826_ _01827_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10001_ _04128_ _04139_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__xnor2_1
XFILLER_76_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05740_ _04865_ _04873_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__nand2b_1
X_05671_ _04146_ _04233_ VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__xnor2_1
X_08390_ net451 net279 net271 net458 VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__a22oi_1
XFILLER_90_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07410_ net200 net596 net587 net208 VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_18_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07341_ _01234_ _01237_ _01075_ _01077_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__o211ai_2
XFILLER_16_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07272_ _01154_ _01163_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__nand2b_1
XFILLER_31_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09011_ _03020_ _03021_ _03059_ _03060_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__or4_1
X_06223_ _00038_ _00043_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__xnor2_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06154_ _05281_ _05282_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06085_ _05212_ _05213_ _05211_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__o21ai_1
Xfanout603 net13 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__buf_2
X_09913_ net322 net559 net544 net330 VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__a22o_1
Xfanout614 net11 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__buf_2
Xfanout625 net626 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__buf_2
X_09844_ net337 net544 _03967_ _03968_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__a22o_1
XFILLER_86_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06987_ _00698_ _00700_ _00850_ _00852_ VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__a211o_1
X_09775_ _03892_ _03893_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08726_ net161 net336 VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__and2_1
X_05938_ _04991_ _05069_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__xor2_1
X_08657_ _02423_ _02519_ _02518_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_53_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05869_ _04999_ _05000_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__nor2_1
X_07608_ net496 net519 net281 net273 VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__and4_1
XFILLER_54_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08588_ _02444_ _02448_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nand2_1
XFILLER_14_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07539_ _01451_ _01452_ _01454_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__nand3_1
X_10550_ _04728_ _04729_ _04731_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__and3_1
XFILLER_10_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10481_ _04658_ _04659_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__nor2_1
X_09209_ net413 net405 net532 net525 VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_118_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_71_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06910_ _00252_ _00766_ _00769_ _00770_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__a211o_1
XFILLER_68_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07890_ _01833_ _01834_ _01836_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__a21o_1
XFILLER_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06841_ _00694_ _00693_ _00692_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__nand3b_1
XFILLER_68_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06772_ _00616_ _00617_ _00478_ _00481_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__o211ai_1
X_09560_ _03518_ _03658_ _03659_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__and3_1
X_08511_ _02464_ _02515_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__xor2_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09491_ net619 net612 net304 net289 VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__nand4_2
X_05723_ _04805_ _04795_ VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__nand2b_1
X_08442_ _02438_ _02439_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__and2b_1
XFILLER_63_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05654_ _04059_ _04048_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_102_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08373_ _02362_ _02363_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__xnor2_1
XFILLER_51_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05585_ net517 net189 net431 net604 VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__a22oi_1
X_07324_ net609 net630 net281 net273 VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__and4_1
X_07255_ _01144_ _01143_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__and2b_1
X_06206_ _00024_ _00025_ _00026_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__a21oi_1
X_07186_ net496 net519 net310 net295 VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__and4_1
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06137_ net631 net361 _05264_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__and3_1
X_06068_ net211 net203 net551 net468 VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_113_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout411 net412 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkbuf_2
Xfanout422 net424 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_2
Xfanout400 net38 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__buf_2
Xfanout455 net456 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__buf_2
Xfanout466 net3 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_4
Xfanout444 net445 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_2
XFILLER_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout477 net478 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__clkbuf_2
Xfanout499 net26 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__buf_2
XFILLER_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout488 net27 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__buf_2
X_09827_ _03947_ _03950_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__xor2_1
XFILLER_104_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09758_ _03858_ _03874_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__nand2_1
XFILLER_104_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08709_ _02731_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__inv_2
XFILLER_64_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09689_ _03797_ _03798_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__xor2_1
XFILLER_42_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10602_ _04714_ _04753_ _04788_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__and3_1
XFILLER_80_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10533_ _04712_ _04713_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__nor2_1
XFILLER_22_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10464_ net539 net261 VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__nand2_1
XFILLER_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10395_ _04503_ _04566_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__xnor2_1
XFILLER_111_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05370_ net487 net257 VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__nand2_1
XFILLER_119_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07040_ _00910_ _00911_ _00761_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__a21oi_1
XFILLER_88_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08991_ _02947_ _02951_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__nand2_1
X_07942_ net457 net450 net309 net294 VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__nand4_1
XFILLER_68_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07873_ net214 net557 VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__nand2_1
XFILLER_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06824_ _00671_ _00672_ _00673_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__a21oi_1
XFILLER_83_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09612_ _03716_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__inv_2
XFILLER_83_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09543_ _03639_ _03640_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__and2b_1
X_06755_ _00597_ _00598_ _00578_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__a21oi_2
XFILLER_70_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06686_ _00524_ _00523_ _00522_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__nand3b_1
X_05706_ _04602_ _04613_ _03919_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__a21o_1
X_09474_ net168 net274 net265 net176 VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__a22oi_1
XFILLER_36_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08425_ _02420_ _02381_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__nand2b_1
XFILLER_12_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05637_ _03864_ _03875_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__nand2_1
XFILLER_24_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08356_ _02343_ _02344_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__xor2_2
XFILLER_51_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07307_ _01092_ _01094_ _01199_ _01200_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__a22o_1
X_05568_ _02151_ _03113_ _03124_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__and3_1
X_08287_ _02102_ _02104_ _02103_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__o21bai_1
X_05499_ net343 net452 net446 net436 VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_115_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07238_ _01111_ _01124_ _01125_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__nand3b_2
X_07169_ _01048_ _01049_ _00900_ _00902_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__a211o_1
XFILLER_117_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10180_ net599 net249 _04253_ _04252_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__a31oi_1
XFILLER_105_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout241 net58 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_2
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_2
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout252 net253 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__buf_2
XFILLER_59_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout274 net275 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_2
Xfanout296 net50 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_4
XFILLER_86_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout285 net51 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10516_ _04693_ _04694_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10447_ _04620_ _04621_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__nor2_1
XFILLER_108_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10378_ _04545_ _04546_ VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06540_ _00243_ _00366_ VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__nor2_1
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06471_ net455 net449 net418 net410 VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__and4_1
X_08210_ _01980_ _02012_ _02011_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__a21oi_1
X_05422_ _01486_ _01519_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__xnor2_1
X_09190_ _03254_ _03256_ _03120_ _03122_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__a211oi_1
X_08141_ _02101_ _02111_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__xnor2_1
X_05353_ _00680_ _00746_ _00768_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__or3_1
XFILLER_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08072_ _01059_ _01210_ _01212_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_99_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07023_ _00853_ _00855_ _00891_ _00892_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__nor4_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_110_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08974_ _02923_ _03018_ _03019_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__and3_1
XFILLER_29_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07925_ _01873_ _01874_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07856_ _01790_ _01798_ _01799_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nand3_1
XFILLER_29_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07787_ net482 net286 _01722_ _01723_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__a22o_1
X_06807_ _00655_ _00656_ _00648_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__nor3b_1
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06738_ _00580_ _00581_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__nor2_1
X_09526_ _03621_ _03622_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__xnor2_1
X_09457_ _03544_ _03545_ _03538_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__a21o_1
X_06669_ _00504_ _00506_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08408_ net547 net464 net308 net293 VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_61_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09388_ _03467_ _03470_ _03471_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_22_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08339_ _02324_ _02325_ _02323_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_50_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10301_ net306 net291 net538 net524 VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__nand4_1
X_10232_ _04047_ _04319_ _04227_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_72_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10163_ net322 net529 net513 net335 VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__a22oi_1
XFILLER_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10094_ _04238_ _04239_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07710_ _01640_ _01641_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__and2b_1
X_05971_ _05011_ _05013_ _05100_ _05101_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__o211ai_2
XFILLER_38_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08690_ _02709_ _02710_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__or2_1
X_07641_ _01563_ _01564_ _01544_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__o21ai_1
XFILLER_93_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07572_ _01327_ _01329_ _01328_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_0_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06523_ _00221_ _00224_ _00345_ _00347_ VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__a211oi_4
X_09311_ _03252_ _03254_ _03386_ _03388_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__a211oi_1
X_06454_ _00271_ _00272_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__nor2_1
XFILLER_33_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09242_ _03304_ _03311_ _03312_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__nand3_1
X_06385_ net218 net180 VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__nand2_1
X_09173_ _03236_ _03237_ _03217_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__a21o_1
X_05405_ _01322_ _01333_ _01344_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__nand3_1
X_08124_ _02051_ _02091_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__xor2_1
X_05336_ _00385_ _00505_ _00560_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__a21o_1
XFILLER_119_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08055_ _01783_ _01847_ _01845_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__a21boi_1
XFILLER_103_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07006_ net437 net347 net573 net566 VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nand4_1
XFILLER_115_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08957_ net188 net430 net526 net510 VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__nand4_1
X_07908_ _01854_ _01855_ _01698_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__a21o_1
X_08888_ _02926_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__inv_2
XFILLER_29_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07839_ _01779_ _01781_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__nor2_1
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09509_ _03600_ _03601_ _03438_ _03441_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_35_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10215_ _04285_ _04289_ _04370_ _04371_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__a211oi_2
XFILLER_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10146_ _04211_ _04214_ _04295_ _04296_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__o211ai_2
X_10077_ _04118_ _04121_ _04220_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__or3_1
XFILLER_47_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06170_ _05293_ _05298_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_96_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09860_ _03983_ _03984_ net626 net261 VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_5_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08811_ _02689_ _02693_ _02688_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__a21bo_1
XFILLER_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09791_ _03903_ _03910_ _03911_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__nand3_2
XFILLER_97_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08742_ _02759_ _02766_ _02767_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__nand3_1
X_05954_ net488 net495 net420 net412 VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__and4_1
X_08673_ _02046_ _02692_ _02691_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__o21ai_2
X_07624_ net475 net316 _01407_ _01406_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__a31o_1
XFILLER_81_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05885_ _04932_ _04934_ _05015_ _05016_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__o211ai_2
XFILLER_53_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07555_ net200 net587 net580 net208 VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_52_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07486_ _01236_ _01238_ _01393_ _01394_ VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__a211o_1
X_06506_ _00325_ _00328_ VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__xnor2_1
X_06437_ _00170_ _00172_ _00150_ VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__o21ai_1
X_09225_ net350 net584 net576 net358 VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_32_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06368_ _00178_ _00186_ VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__xnor2_1
X_09156_ net169 net313 _03024_ _03023_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__a31o_1
XFILLER_107_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08107_ net444 net309 net294 net450 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__a22o_1
X_06299_ _00101_ _00118_ _00119_ VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__and3_1
X_05319_ _00331_ _00342_ _00396_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__a21o_1
X_09087_ _03141_ _03142_ _03135_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__or3b_1
XFILLER_107_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08038_ _01997_ _01998_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__nor2_1
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10000_ _04134_ _04135_ _04137_ _03267_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__a22o_1
XFILLER_88_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09989_ _04123_ _04124_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__and2_1
XFILLER_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10129_ _04188_ _04191_ _04275_ _04276_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__a211o_1
XFILLER_48_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05670_ _04146_ _04233_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__and2b_1
XFILLER_90_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07340_ _01075_ _01077_ _01234_ _01237_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__a211o_2
XTAP_TAPCELL_ROW_18_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07271_ _01155_ _01161_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__xnor2_1
X_09010_ _03020_ _03021_ _03059_ _03060_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__nor4_1
X_06222_ _00043_ _00038_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__and2b_1
X_06153_ _05181_ _05183_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__nand2_1
X_06084_ _05211_ _05212_ _05213_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__or3_1
Xfanout615 net616 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__buf_2
X_09912_ net330 net322 net559 net544 VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__and4_1
Xfanout604 net605 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__buf_2
XFILLER_112_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout626 net10 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__clkbuf_4
X_09843_ net352 net536 net526 net360 VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__a22o_1
X_06986_ _00698_ _00700_ _00850_ _00852_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__a211oi_1
XFILLER_73_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09774_ net169 net248 VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__and2_1
XFILLER_85_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08725_ net360 net616 net352 net621 VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__a22o_1
X_05937_ _05067_ _05068_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__xnor2_2
X_08656_ _02582_ _02673_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__xnor2_1
X_05868_ net495 net420 net412 net518 VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__a22oi_1
X_07607_ _01516_ _01518_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__nor2_1
XFILLER_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08587_ _02587_ _02597_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__xnor2_1
XFILLER_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07538_ net427 net618 net602 net185 VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__a22o_1
X_05799_ _04931_ _04930_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__and2b_1
X_07469_ _01375_ _01377_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__nand2_1
XFILLER_10_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10480_ net291 net283 net508 net501 VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__and4_1
X_09208_ _03273_ _03274_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_118_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09139_ net297 net275 net267 net385 VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06840_ net426 net301 VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__nand2_1
XFILLER_68_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06771_ _00478_ _00481_ _00616_ _00617_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__a211o_1
XFILLER_82_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08510_ _02511_ _02513_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__xnor2_1
X_09490_ net612 net312 _03405_ _03404_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__a31o_1
X_05722_ _04016_ _04038_ _04005_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o21ba_1
X_08441_ _02434_ _02436_ _02437_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__a21o_1
X_05653_ _03319_ _03341_ _03308_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_102_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08372_ _02363_ _02362_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__nand2b_1
XFILLER_51_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05584_ net517 net604 net189 net431 VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__and4_1
X_07323_ net609 net281 net273 net630 VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__a22o_1
X_07254_ _00985_ _00987_ _00986_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__o21ba_1
XFILLER_31_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06205_ _00024_ _00025_ _00026_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__and3_1
X_07185_ _00941_ _00943_ _00942_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__o21ba_1
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06136_ net631 net361 VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__nand2_1
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06067_ net195 net447 VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_113_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout423 net424 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_1
Xfanout401 net402 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_2
XFILLER_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout412 net37 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__buf_2
Xfanout456 net31 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__buf_4
Xfanout445 net32 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__buf_2
XFILLER_98_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout434 net34 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_2
Xfanout478 net29 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_4
Xfanout489 net27 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__buf_2
XFILLER_104_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout467 net3 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__buf_2
XFILLER_48_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09826_ _03740_ _03949_ _03948_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__o21ai_1
X_06969_ net389 net418 net301 net410 VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__and4_1
XFILLER_46_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09757_ _03873_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__inv_2
XFILLER_104_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08708_ _02569_ _02571_ _02728_ _02729_ VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__o211ai_2
XFILLER_73_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09688_ _03797_ _03798_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__or2_1
X_08639_ _02652_ _02653_ _02489_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__a21o_1
XFILLER_14_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10601_ _04785_ _04786_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__xnor2_1
XFILLER_80_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10532_ _04712_ _04713_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__and2_1
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10463_ _04638_ _04639_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__nor2_1
X_10394_ _04506_ _04564_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08990_ _03028_ _03038_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__xnor2_2
X_07941_ net451 net317 _01748_ _01746_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__a31o_1
XFILLER_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07872_ _01808_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__xor2_1
XFILLER_68_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06823_ _00674_ VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__inv_2
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09611_ _03671_ _03714_ _03715_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__and3_1
XFILLER_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06754_ _00578_ _00597_ _00598_ VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__nand3_1
X_09542_ _03636_ _03637_ _03638_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__a21o_1
X_05705_ _03919_ _04602_ _04613_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__nand3_2
XFILLER_91_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06685_ net476 net371 VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand2_1
XFILLER_70_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09473_ net176 net168 net274 net265 VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__and4_1
X_08424_ _02398_ _02419_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__xor2_1
X_05636_ _02151_ _03124_ _03113_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__a21bo_1
XFILLER_24_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08355_ _02343_ _02344_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__nor2_1
XFILLER_51_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05567_ _03091_ _03102_ _02523_ _02555_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__a211o_1
X_07306_ _01092_ _01094_ _01199_ _01200_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__nand4_2
X_08286_ _02266_ _02267_ _02265_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05498_ net436 net343 net452 net446 VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__and4_1
X_07237_ _00964_ _00966_ _01123_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__nand3_1
XFILLER_117_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07168_ _00900_ net132 _01048_ _01049_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__o211ai_4
X_06119_ _05237_ _05239_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__nor2_1
X_07099_ _00851_ _00854_ net153 _00974_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__a211oi_2
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_4
Xfanout231 net232 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_2
XFILLER_115_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout264 net54 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_2
Xfanout253 net56 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout242 net245 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_4
Xfanout286 net288 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_4
XFILLER_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout297 net299 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_2
Xfanout275 net52 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_4
X_09809_ _03783_ _03829_ _03929_ _03931_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__o211a_1
XFILLER_86_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10515_ _04694_ _04693_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__nand2b_1
XFILLER_109_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10446_ _04620_ _04621_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__and2_1
X_10377_ _04546_ _04545_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__nand2b_1
XFILLER_111_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06470_ _00286_ _00288_ _00165_ _00168_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__o211a_1
X_05421_ _01519_ _01486_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__and2b_1
XFILLER_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08140_ _02109_ _02110_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__and2b_1
X_05352_ _00746_ _00768_ _00680_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__o21ai_2
X_08071_ _01692_ _01696_ _01863_ _01864_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_99_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07022_ _00888_ _00890_ _00737_ _00740_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__o211a_1
XFILLER_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08973_ _03018_ _03019_ _02923_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__a21oi_1
XFILLER_114_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07924_ net482 net280 net271 net489 VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__a22oi_1
XFILLER_68_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07855_ _01795_ _01796_ _01797_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_119_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07786_ net458 net309 net294 net474 VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__a22o_1
X_06806_ _00652_ _00653_ _00654_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__a21oi_1
XFILLER_83_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06737_ net232 net617 net602 net239 VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__a22oi_1
X_09525_ _03508_ _03510_ _03506_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__a21oi_1
X_06668_ net631 net318 VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__nand2_1
XFILLER_52_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09456_ _03538_ _03544_ _03545_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__nand3_1
X_08407_ net464 net316 _02261_ _02259_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_61_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05619_ _03592_ _03668_ _03679_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__nand3_1
X_06599_ _00426_ _00427_ _00303_ _00305_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__a211oi_2
XFILLER_51_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09387_ net168 net282 _03468_ _03469_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_22_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08338_ _02323_ _02324_ _02325_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_50_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08269_ _02082_ _02084_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__nor2_1
X_10300_ net314 net523 _04384_ _04383_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__a31o_1
XFILLER_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10231_ _04388_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__inv_2
XFILLER_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10162_ net335 net322 net529 net513 VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__and4_1
X_10093_ net315 net545 VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__nand2_1
XFILLER_59_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10429_ net555 net261 VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__nand2_1
XFILLER_112_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05970_ _05098_ _05099_ _05084_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__a21o_1
XFILLER_111_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07640_ _01544_ _01563_ _01564_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__or3_1
XFILLER_38_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07571_ _01487_ _01488_ _01485_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a21o_1
XFILLER_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06522_ _00343_ _00344_ _00324_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__a21oi_2
X_09310_ _03382_ _03384_ _03213_ _03216_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__o211a_1
X_06453_ net476 net397 net380 net484 VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__a22oi_1
X_09241_ _03309_ _03310_ _03305_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__a21o_1
X_06384_ _00194_ _00202_ VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__xnor2_1
X_09172_ _03217_ _03236_ _03237_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__nand3_2
X_05404_ _00962_ _00973_ _00951_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__o21bai_1
XFILLER_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08123_ _02091_ _02051_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__nand2b_1
X_05335_ _00287_ _00582_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__nor2_1
XFILLER_119_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08054_ _01956_ _02016_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__xor2_1
X_07005_ net256 net581 VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__and2_1
XFILLER_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08956_ net430 net509 VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__nand2_1
XFILLER_102_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07907_ _01698_ _01854_ _01855_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__nand3_1
X_08887_ _02792_ _02819_ _02923_ _02924_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__a211oi_2
X_07838_ _01777_ _01778_ _01627_ _01630_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__o211a_1
XFILLER_29_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07769_ net519 net264 VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_55_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09508_ _03438_ _03441_ _03600_ _03601_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__o211ai_1
XFILLER_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09439_ net350 net569 net562 net358 VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_35_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10214_ _04368_ _04369_ _04291_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_7_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10145_ _04293_ _04294_ _04204_ _04207_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a211o_1
XFILLER_67_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10076_ _04118_ _04121_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__nor3_1
XFILLER_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08810_ _02841_ _02842_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__nor2_1
XFILLER_97_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09790_ _03907_ _03909_ _03904_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__a21o_1
XFILLER_100_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08741_ _02764_ _02765_ _02760_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__a21o_1
X_05953_ _05019_ _05026_ _05025_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__a21o_1
X_08672_ _02207_ _02208_ _02690_ _02035_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__or4b_2
X_05884_ _04947_ _04949_ _05014_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__nand3_1
X_07623_ net496 net288 _01383_ _01381_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__a31o_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07554_ net208 net200 net587 net580 VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nand4_1
XFILLER_53_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07485_ _01236_ _01238_ _01393_ _01394_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_105_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06505_ _00326_ _00327_ VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__nor2_1
X_06436_ _00248_ _00254_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__xnor2_1
XFILLER_22_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09224_ net358 net350 net584 net576 VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__nand4_1
XFILLER_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06367_ _00178_ _00186_ VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__and2_1
X_09155_ _03088_ _03092_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__nand2_1
XFILLER_5_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08106_ net450 net443 net309 net294 VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__nand4_2
X_06298_ _00115_ _00116_ _00117_ VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__a21o_1
X_05318_ _00331_ _00342_ _00396_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__nand3_1
X_09086_ _03141_ _03142_ _03135_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__nor3b_1
X_08037_ net344 net256 net510 net503 VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__and4_1
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09988_ _04123_ _04124_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__nor2_1
XFILLER_88_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08939_ _02980_ _02981_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__xnor2_1
XFILLER_76_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10128_ _04188_ _04191_ _04275_ _04276_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__a211oi_1
XFILLER_95_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10059_ _04199_ _04200_ _04180_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__a21oi_1
XFILLER_75_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07270_ _01155_ _01161_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__nand2b_1
X_06221_ _05070_ _00042_ _00040_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__o21ba_1
X_06152_ _05277_ _05280_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__xnor2_1
XFILLER_8_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06083_ net347 net172 net164 net440 VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__a22oi_2
X_09911_ _03956_ _04040_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__xor2_1
Xfanout605 net607 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__buf_2
Xfanout616 net11 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__buf_2
X_09842_ net360 net352 net536 net526 VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__nand4_1
Xfanout627 net628 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__buf_2
XFILLER_98_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09773_ _03889_ _03890_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06985_ _00715_ _00717_ _00849_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__and3_1
X_08724_ net621 net360 net616 net352 VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__nand4_1
XFILLER_39_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05936_ _04911_ _04987_ _04985_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__o21a_1
X_08655_ _02670_ _02671_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__xor2_1
XFILLER_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05867_ net495 net518 net420 net412 VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__and4_1
XFILLER_26_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07606_ _01526_ _01527_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__xnor2_1
X_08586_ _02595_ _02596_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__and2b_1
XFILLER_54_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07537_ net185 net427 net618 net602 VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_66_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05798_ _04763_ _04784_ _04752_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__o21ba_1
XFILLER_41_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07468_ _01220_ _01374_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__or2_1
X_07399_ _01292_ _01301_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__and2_1
X_06419_ _00144_ _00238_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__and2b_1
XFILLER_10_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09207_ _03136_ _03139_ _03273_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_118_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09138_ net385 net297 net275 net267 VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__and4_1
XFILLER_118_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09069_ _02846_ _02984_ _02983_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__o21a_1
XFILLER_118_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10677_ _00898_ _04861_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_93_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06770_ _00478_ _00481_ _00616_ _00617_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__a211oi_1
XFILLER_83_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05721_ _04773_ _04784_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__xnor2_1
X_08440_ _02434_ _02436_ _02437_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__and3_1
X_05652_ _04027_ _04038_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__xnor2_1
XFILLER_23_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08371_ _02049_ _02198_ _02197_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__a21oi_1
X_05583_ net141 _02632_ _03156_ _03167_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__and4_1
X_07322_ _01091_ _01094_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__and2b_1
X_07253_ _01139_ _01142_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07184_ _00921_ _00924_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__nand2_1
X_06204_ _05172_ _05233_ _05232_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__a21bo_1
XFILLER_117_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06135_ _05262_ _05263_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__xor2_1
XFILLER_117_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06066_ _05116_ _05118_ _05115_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_113_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout402 net38 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkbuf_4
Xfanout413 net414 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkbuf_2
Xfanout457 net458 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_2
Xfanout446 net447 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__buf_2
Xfanout435 net436 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__buf_2
X_09825_ _03736_ _03845_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__nand2_1
Xfanout424 net35 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__clkbuf_4
Xfanout468 net3 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__buf_1
Xfanout479 net480 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__buf_2
X_06968_ net469 net403 VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__nand2_1
X_09756_ _03863_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08707_ _02725_ _02726_ _02564_ _02567_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__o211ai_2
X_09687_ net219 net242 VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__nand2_1
X_05919_ _05047_ _05049_ _04967_ _04970_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__o211ai_2
X_06899_ _00500_ _00756_ _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__nand3_1
XFILLER_82_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08638_ _02489_ _02652_ _02653_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__nand3_1
XFILLER_81_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08569_ _02556_ _02576_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__xnor2_1
XFILLER_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10600_ _04786_ _04785_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_12_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10531_ _04596_ _04662_ _04664_ _04655_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_40_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10462_ net531 net270 net523 net278 VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__a22oi_1
XFILLER_108_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10393_ _04506_ _04564_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__nand2_1
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07940_ _01722_ _01726_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__nand2_1
XFILLER_110_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07871_ _01815_ _01816_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__and2b_1
XFILLER_68_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06822_ _00671_ _00672_ _00673_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__and3_1
XFILLER_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09610_ _03710_ _03713_ _03556_ _03558_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__o211ai_1
X_06753_ _00578_ _00597_ _00598_ VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__and3_1
X_09541_ _03636_ _03637_ _03638_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__and3_1
XFILLER_83_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05704_ _04581_ _04591_ _03886_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__o21ai_1
X_06684_ net454 net396 net379 net461 VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__a22o_1
XFILLER_63_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09472_ _03561_ _03562_ _03443_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__or3b_2
X_08423_ _02417_ _02418_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__nand2_1
XFILLER_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05635_ _03843_ _03853_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__and2_1
X_08354_ _02167_ _02180_ _02179_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_63_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05566_ _02523_ _02555_ _03091_ _03102_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__o211ai_1
X_07305_ _01197_ _01198_ _01041_ net139 VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__a211o_1
X_08285_ _02265_ _02266_ _02267_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__or3_1
XFILLER_50_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05497_ net257 net459 VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__nand2_1
X_07236_ _00964_ _00966_ _01123_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__a21o_1
X_07167_ _01045_ _01046_ _00940_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__o21ai_2
XFILLER_105_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06118_ _05156_ _05247_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__xnor2_1
X_07098_ _00968_ _00970_ _00955_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__o21a_1
XFILLER_59_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout221 net225 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
Xfanout232 net233 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_2
X_06049_ _05175_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__xnor2_1
Xfanout210 net61 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_2
Xfanout243 net245 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_4
Xfanout265 net267 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
Xfanout254 net55 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__buf_2
Xfanout298 net299 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_4
Xfanout287 net288 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout276 net277 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_2
X_09808_ _03881_ _03882_ _03926_ _03927_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__a22o_1
XFILLER_46_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09739_ _03851_ _03852_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__xnor2_1
XFILLER_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10514_ _04639_ _04641_ _04638_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__o21ba_1
XFILLER_109_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10445_ _04540_ _04558_ _04539_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__a21o_1
XFILLER_6_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10376_ _04484_ _04486_ _04482_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__o21ba_1
XFILLER_111_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05420_ _01497_ _01508_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__or2_1
X_05351_ net235 net629 _00757_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__and3_1
XFILLER_119_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08070_ _02031_ _02033_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_99_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07021_ _00737_ _00740_ _00888_ _00890_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__a211oi_2
XFILLER_114_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08972_ _02647_ _02895_ _03016_ _03017_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_110_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07923_ net482 net489 net279 net271 VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__and4_1
XFILLER_110_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07854_ _01795_ _01796_ _01797_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__nand3_1
XFILLER_68_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06805_ _00652_ _00653_ _00654_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__and3_1
XFILLER_83_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07785_ net474 net458 net309 net294 VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nand4_1
X_06736_ net239 net232 net617 net602 VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__and4_1
XFILLER_36_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09524_ _03619_ _03620_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__nor2_1
X_06667_ _00502_ _00503_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__and2b_1
XFILLER_52_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09455_ _03542_ _03543_ _03539_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__a21o_1
X_08406_ _02236_ _02240_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__nand2_1
XFILLER_51_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05618_ _03635_ _03646_ _03657_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__a21o_1
X_06598_ _00303_ _00305_ _00426_ _00427_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__o211ai_2
XFILLER_51_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09386_ net168 net282 _03468_ _03469_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_22_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08337_ net199 net541 net534 net210 VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__a22o_1
X_05549_ _02894_ _02905_ _02818_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__a21o_1
X_08268_ _02247_ _02248_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_50_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07219_ _00946_ _00948_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__nor2_1
X_08199_ _02168_ _02172_ _02174_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__and3_1
X_10230_ _04386_ _04387_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10161_ net338 net505 _04047_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__and3_1
X_10092_ _04236_ _04237_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__and2b_1
XFILLER_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10428_ _04600_ _04601_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__nor2_1
XFILLER_112_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10359_ _04524_ _04525_ net284 net538 VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__and4bb_1
XFILLER_112_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07570_ _01485_ _01487_ _01488_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__nand3_1
XFILLER_18_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06521_ _00324_ _00343_ _00344_ VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__nand3_2
XFILLER_33_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09240_ _03305_ _03309_ _03310_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__nand3_1
X_06452_ net484 net476 net397 net380 VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__and4_1
XFILLER_21_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06383_ _00194_ _00202_ VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__nand2b_1
X_09171_ _03234_ _03235_ _03097_ _03099_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__a211o_1
X_05403_ _01289_ _01300_ _01311_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__o21ai_1
X_08122_ _02069_ _02090_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__xnor2_1
X_05334_ net234 net605 net629 net228 VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__a22oi_1
X_08053_ _02013_ _02014_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__xnor2_1
X_07004_ _00868_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__xnor2_1
X_08955_ _02998_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__xnor2_1
X_07906_ _01852_ _01853_ _01678_ _01680_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__a211o_1
XFILLER_57_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08886_ _02923_ _02924_ _02792_ _02819_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__o211a_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07837_ _01627_ _01630_ _01777_ _01778_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__a211oi_1
X_07768_ _01701_ _01702_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__nor2_1
XFILLER_56_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06719_ _00544_ _00559_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__nand3_2
XFILLER_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09507_ _03438_ _03441_ _03600_ _03601_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__o211a_1
XFILLER_37_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07699_ _01609_ _01627_ _01629_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__nand3_2
XFILLER_12_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09438_ net358 net350 net569 net562 VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__nand4_1
XFILLER_24_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09369_ _03449_ _03451_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__nor2_1
XFILLER_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10213_ _04291_ _04368_ _04369_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__and3_1
XFILLER_106_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10144_ net137 _04207_ _04293_ _04294_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__o211ai_4
XFILLER_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10075_ _04218_ _04219_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__xnor2_1
XFILLER_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08740_ _02760_ _02764_ _02765_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__nand3_1
X_05952_ _05081_ _05082_ VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__nor2_1
X_08671_ _02369_ _02532_ _02690_ _02373_ _02530_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__o221a_1
XFILLER_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05883_ _04947_ _04949_ _05014_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__a21o_1
X_07622_ _01411_ _01419_ _01418_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__a21o_1
XFILLER_66_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_105_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07553_ net193 net596 VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07484_ _01391_ _01392_ _01230_ _01232_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_105_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06504_ net230 net164 net624 net240 VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__a22oi_1
XFILLER_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06435_ _00249_ _00254_ VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__nor2_1
X_09223_ _03290_ _03291_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__xnor2_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09154_ _03028_ _03037_ _03035_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__a21o_1
X_08105_ net443 net317 _01920_ _01919_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__a31o_1
X_06366_ _00183_ _00184_ VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__xnor2_1
X_06297_ _00115_ _00116_ _00117_ VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__nand3_4
X_05317_ _00364_ _00374_ _00353_ VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__o21bai_1
X_09085_ _03138_ _03139_ _03140_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08036_ net256 net510 net503 net344 VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__a22oi_1
XFILLER_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09987_ _04031_ _04033_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__nor2_1
X_08938_ _02980_ _02981_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_4_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08869_ _02904_ _02906_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10127_ _04273_ _04274_ _04263_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10058_ _04180_ _04199_ _04200_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__and3_1
XFILLER_35_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06220_ _00041_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__inv_2
X_06151_ _05278_ _05279_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__nor2_1
X_06082_ net440 net347 net172 net164 VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__and4_1
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09910_ _03742_ _03953_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__nor2_1
Xfanout606 net607 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__buf_2
XFILLER_98_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout617 net11 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__buf_2
X_09841_ _03964_ _03965_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__xnor2_1
Xfanout628 net1 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__buf_2
X_06984_ _00850_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_13_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09772_ _03890_ _03889_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__and2b_1
XFILLER_85_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08723_ _02745_ _02746_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__xnor2_1
X_05935_ _04983_ _05065_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__xor2_4
XFILLER_39_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08654_ _02670_ _02671_ VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__nand2_1
XFILLER_26_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05866_ _04996_ _04997_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__nor2_1
X_07605_ _01217_ _01369_ _01367_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__o21bai_1
XFILLER_81_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08585_ _02592_ _02593_ _02594_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__a21o_1
XFILLER_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05797_ _04928_ _04929_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__xnor2_1
X_07536_ net422 net625 VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_66_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07467_ _01220_ _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__nand2_1
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09206_ _03136_ _03139_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__nand2_1
X_07398_ _01297_ _01298_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__xnor2_1
X_06418_ _00236_ _00237_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_118_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06349_ _00164_ _00166_ _00152_ VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__o21a_1
X_09137_ _03103_ _03105_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__nand2_1
X_09068_ _03122_ _03123_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__or2_2
XFILLER_118_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08019_ _01974_ _01976_ _01798_ _01800_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__o211ai_1
XFILLER_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10676_ _00800_ _00887_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__or2_1
XFILLER_40_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05720_ net517 net425 VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__nand2_1
XFILLER_91_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05651_ net604 net425 VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__nand2_1
XFILLER_36_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08370_ _02212_ _02361_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07321_ _01064_ _01213_ _01216_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__a21oi_2
X_05582_ _03233_ _03276_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__xnor2_1
X_07252_ _01140_ _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nor2_1
X_07183_ _00945_ _00954_ _00952_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__a21oi_1
X_06203_ _00022_ _00023_ _05270_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__o21ai_1
X_06134_ _05072_ _05164_ _05163_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06065_ _05107_ _05110_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_113_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout403 net404 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkbuf_4
Xfanout414 net421 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout447 net32 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout436 net33 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__buf_2
Xfanout425 net35 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__clkbuf_4
X_09824_ _03735_ _03842_ _03844_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__a21oi_1
Xfanout458 net463 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__buf_2
Xfanout469 net470 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__buf_2
X_06967_ _00829_ _00830_ _00675_ _00678_ VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__o211a_1
XFILLER_67_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09755_ _03870_ _03871_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__and2b_1
XFILLER_39_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06898_ _00754_ _00755_ _00613_ _00616_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__a211o_1
X_08706_ _02564_ _02567_ _02725_ _02726_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_68_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09686_ _03795_ _03796_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__xnor2_1
X_05918_ _04967_ _04970_ _05047_ _05049_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__a211o_1
X_08637_ _02651_ _02650_ _02649_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__nand3b_1
X_05849_ _04902_ _04904_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__nor2_1
XFILLER_82_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08568_ _02556_ _02576_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__and2_1
XFILLER_14_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07519_ _01429_ _01430_ _01423_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__a21oi_1
XFILLER_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08499_ _02491_ _02500_ _02502_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_12_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10530_ _04706_ _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__xor2_1
X_10461_ net278 net531 net270 net523 VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__and4_1
XFILLER_10_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10392_ _04460_ _04562_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__xor2_1
XFILLER_96_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10659_ net500 net242 _04846_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__a21oi_1
XFILLER_79_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07870_ _01812_ _01814_ _01809_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a21o_1
XFILLER_110_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06821_ _00520_ _00529_ _00528_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__a21bo_1
XFILLER_68_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06752_ _00594_ _00595_ _00596_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__a21o_1
XFILLER_49_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09540_ _03528_ _03529_ _03527_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__a21bo_1
XFILLER_36_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05703_ _03886_ _04581_ _04591_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__or3_1
X_09471_ _03561_ _03562_ _03443_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__o21bai_1
X_08422_ _02415_ _02416_ _02245_ _02247_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__a211o_1
X_06683_ net461 net454 net396 net379 VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__nand4_1
XFILLER_24_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05634_ _03821_ _03832_ _03058_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_63_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08353_ _02333_ _02342_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_63_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05565_ _03003_ _03014_ _03080_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__a21o_1
X_07304_ _01041_ net139 _01197_ _01198_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__o211ai_4
X_08284_ net171 net363 net355 net179 VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__a22oi_2
X_07235_ _01112_ _01121_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05496_ _02326_ _02337_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__xnor2_1
X_07166_ _00940_ _01045_ _01046_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__or3_2
X_07097_ _00971_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__inv_2
XFILLER_3_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06117_ _05153_ _05245_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__xnor2_1
X_06048_ _05176_ _05177_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__nor2_1
XFILLER_99_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout222 net225 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout211 net213 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
Xfanout200 net62 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_2
XFILLER_115_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout233 net59 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_2
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_2
Xfanout299 net5 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__clkbuf_4
Xfanout288 net51 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07999_ _01808_ _01816_ _01815_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__a21o_1
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__buf_1
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlymetal6s2s_1
X_09807_ _03881_ _03882_ _03926_ _03927_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__nand4_1
X_09738_ _03852_ _03851_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__and2b_1
XFILLER_55_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09669_ _03776_ _03778_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__and2b_1
XFILLER_27_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10513_ _04691_ _04692_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10444_ _04599_ _04618_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__xnor2_1
XFILLER_109_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10375_ _04543_ _04544_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__xnor2_1
XFILLER_111_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05350_ _00691_ _00735_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__xnor2_1
XFILLER_119_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07020_ _00885_ _00886_ _00867_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08971_ _02647_ _02895_ _03016_ _03017_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__or4bb_2
XTAP_TAPCELL_ROW_110_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07922_ _01745_ _01781_ _01779_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__o21bai_1
X_07853_ _01616_ _01619_ _01618_ VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__o21bai_1
XFILLER_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06804_ net499 net339 _00509_ _00508_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__a31o_1
XFILLER_110_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07784_ net458 net317 _01572_ _01571_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__a31o_1
XFILLER_71_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06735_ net216 net624 VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__nand2_1
XFILLER_52_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09523_ _03499_ _03503_ _03617_ _03618_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__a211oi_1
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06666_ net520 net334 net327 net611 VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__a22o_1
X_09454_ _03539_ _03542_ _03543_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__nand3_1
XFILLER_36_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08405_ _02264_ _02273_ _02272_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__a21o_1
XFILLER_52_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09385_ net619 net304 net289 net159 VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__a22o_1
X_05617_ _03635_ _03646_ _03657_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__nand3_1
X_06597_ _00303_ _00305_ _00426_ _00427_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__o211a_1
X_08336_ net210 net198 net541 net534 VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__nand4_1
XFILLER_52_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05548_ _02818_ _02894_ _02905_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nand3_1
X_08267_ _02245_ _02246_ _02078_ _02080_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_50_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05479_ net627 net189 _01955_ _01977_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__a211oi_1
X_07218_ _01100_ _01103_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08198_ _02170_ _02171_ _02169_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__o21ai_1
X_07149_ _00872_ _00881_ _00880_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__a21bo_1
XFILLER_106_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10160_ _04308_ _04312_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__xnor2_1
XFILLER_87_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10091_ net323 net537 net529 net330 VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__a22o_1
XFILLER_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10427_ net278 net531 net270 net539 VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__a22oi_1
X_10358_ net284 net538 _04524_ _04525_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_112_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10289_ _04308_ _04379_ _04380_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06520_ _00324_ _00343_ _00344_ VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__and3_1
XFILLER_18_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06451_ _00174_ _00176_ _00175_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_60_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05402_ _01289_ _01300_ _01311_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__or3_1
XFILLER_33_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06382_ _00195_ _00200_ VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__xnor2_1
X_09170_ _03097_ _03099_ _03234_ _03235_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__o211ai_4
XFILLER_119_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08121_ _02087_ _02088_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__xnor2_1
X_05333_ _00385_ _00505_ _00560_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__and3_1
XFILLER_107_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08052_ _02013_ _02014_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_78_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07003_ _00869_ _00870_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__nor2_1
XFILLER_102_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08954_ net399 net565 VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__nand2_1
XFILLER_102_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07905_ _01678_ _01680_ _01852_ _01853_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_71_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08885_ _02921_ _02922_ _02900_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__a21oi_1
X_07836_ _01775_ _01776_ _01762_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__o21a_1
X_07767_ net489 net52 net273 net496 VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__a22oi_1
XFILLER_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06718_ _00557_ _00558_ _00550_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_55_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09506_ _03598_ _03599_ _03580_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__a21o_1
X_07698_ _01625_ _01626_ _01610_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__a21o_1
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06649_ _00256_ _00483_ _00485_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__nor3_1
X_09437_ _03523_ _03524_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09368_ _03447_ _03448_ net297 net258 VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_35_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08319_ net184 net427 net571 net564 VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__and4_1
X_09299_ _03329_ _03331_ _03373_ _03375_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__nand4_2
XFILLER_21_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10212_ _04366_ _04367_ _04321_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10143_ net130 _04292_ _04209_ VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__o21ai_2
XFILLER_102_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10074_ _04075_ _04076_ _04079_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__o21ba_1
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05951_ _05015_ _05017_ _05080_ VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__and3_1
X_08670_ _02532_ _02372_ _02530_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__or3b_1
X_05882_ _05004_ _05012_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__xnor2_1
X_07621_ _01542_ _01543_ VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__or2_1
XFILLER_81_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07552_ _01321_ _01324_ _01323_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__o21bai_1
XFILLER_81_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06503_ net240 net230 net164 net624 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_52_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07483_ _01230_ _01232_ _01391_ _01392_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_105_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06434_ _00252_ _00253_ VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__nor2_1
XFILLER_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09222_ net619 net312 VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_86_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06365_ _00184_ _00183_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__and2b_1
X_09153_ _03214_ _03215_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_32_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08104_ _01894_ _01897_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__nand2_1
XFILLER_108_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05316_ _00353_ _00364_ _00374_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__or3_1
X_06296_ _00000_ _00008_ _00007_ VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__a21bo_1
X_09084_ _03138_ _03139_ _03140_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__and3_1
X_08035_ _01992_ _01995_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09986_ _04121_ _04122_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__or2_1
XFILLER_103_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_95_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08937_ _02695_ _02833_ _02832_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_4_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08868_ net400 net572 VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__nand2_1
X_07819_ _01755_ _01756_ _01757_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__a21o_1
XFILLER_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08799_ _02582_ _02673_ _02672_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__a21boi_1
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10126_ _04263_ _04273_ _04274_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__and3_1
XFILLER_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10057_ _04196_ _04197_ _04094_ _04096_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__a211o_1
XFILLER_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06150_ net447 net190 net433 net456 VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__a22oi_1
XFILLER_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06081_ net254 net183 VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__nand2_1
XFILLER_104_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout618 net11 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__buf_2
Xfanout607 net12 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlymetal6s2s_1
X_09840_ net314 net573 VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nand2_1
Xfanout629 net1 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__buf_2
X_06983_ _00715_ _00717_ _00849_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__a21oi_2
X_09771_ _03785_ _03789_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__nor2_1
XFILLER_100_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08722_ net220 net313 VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__nand2_1
X_05934_ _04983_ _05065_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__and2_1
XFILLER_66_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08653_ _02464_ _02515_ _02514_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_37_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05865_ _04936_ _04938_ _04995_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__and3_1
X_07604_ _01523_ _01525_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__or2_1
XFILLER_81_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08584_ _02592_ _02593_ _02594_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__and3_1
XFILLER_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05796_ net495 net425 VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__nand2_1
X_07535_ _01446_ _01449_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__xnor2_1
X_07466_ _01372_ _01373_ VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_66_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06417_ _00233_ _00235_ _00128_ _00130_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__o211a_1
XFILLER_10_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09205_ _03271_ _03272_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__or2_1
X_07397_ _01298_ _01297_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_118_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06348_ _00152_ _00164_ _00166_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__or3_1
X_09136_ _03195_ _03196_ _03022_ _03062_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__o211a_1
XFILLER_108_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06279_ _00091_ _00099_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__nand2b_1
X_09067_ _03120_ _03121_ _02994_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__o21a_1
X_08018_ _01798_ _01800_ _01974_ _01976_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__a211o_1
XFILLER_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09969_ _04101_ _04102_ _03980_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__a21o_1
XFILLER_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10675_ _00887_ _04860_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__nor2_1
XFILLER_9_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10109_ _04166_ _04167_ _04170_ _04173_ VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__o31a_1
XFILLER_76_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05650_ _04005_ _04016_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__nor2_1
XFILLER_91_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05581_ net135 _02130_ _03255_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_102_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07320_ _01058_ _01212_ _01210_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__o21ba_1
X_07251_ net429 net166 net625 net187 VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_42_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07182_ _00777_ _00927_ _00926_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__a21o_1
X_06202_ _05270_ _00022_ _00023_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__or3_1
X_06133_ _05252_ _05260_ VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__xnor2_1
XFILLER_117_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06064_ _05192_ _05193_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_113_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout404 net38 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__buf_2
XFILLER_113_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_2
Xfanout415 net416 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__buf_2
Xfanout426 net35 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout437 net438 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__buf_2
X_09823_ _03944_ _03945_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__xor2_2
Xfanout459 net460 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_2
X_06966_ _00675_ _00678_ _00829_ _00830_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__a211oi_1
X_09754_ _03867_ _03868_ _03869_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__a21o_1
XFILLER_100_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06897_ _00613_ _00616_ _00754_ _00755_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__o211ai_2
X_08705_ _02564_ _02567_ _02725_ _02726_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_68_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05917_ _05045_ _05046_ _05028_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__a21oi_1
X_09685_ _03680_ _03682_ _03678_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__a21oi_1
X_08636_ _02649_ _02650_ _02651_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__a21bo_1
X_05848_ _04979_ _04980_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__nand2_1
XFILLER_82_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08567_ _02574_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__nor2_1
X_05779_ _04602_ _04624_ _04912_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__nand3_1
X_07518_ _01423_ _01429_ _01430_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__and3_1
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08498_ _02498_ _02499_ _02492_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_12_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07449_ _01248_ _01249_ _01354_ _01356_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__and4_1
X_10460_ net570 net244 _04616_ _04615_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_79_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09119_ _03176_ _03177_ _03173_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__a21o_1
X_10391_ _04460_ _04562_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__nor2_1
XFILLER_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10658_ net500 net242 _04846_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__and3_1
X_10589_ _04727_ _04733_ _04772_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__o21a_1
X_06820_ _00668_ _00670_ _00661_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__a21o_1
XFILLER_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06751_ _00594_ _00595_ _00596_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nand3_2
XFILLER_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06682_ _00411_ _00413_ _00410_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__o21bai_1
XFILLER_64_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05702_ _04559_ _04570_ _03821_ _03843_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__o211a_1
X_09470_ _03558_ _03560_ _03520_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08421_ _02245_ _02247_ _02415_ _02416_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__o211ai_1
XFILLER_91_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05633_ _03058_ _03821_ _03832_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__nand3_2
XFILLER_36_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08352_ _02340_ _02341_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__and2b_1
XFILLER_51_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05564_ _03003_ _03014_ _03080_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__nand3_2
X_07303_ _01131_ _01132_ _01195_ _01196_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__a2bb2o_1
X_08283_ net178 net170 net363 net355 VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__and4_1
X_05495_ net486 net217 VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__nand2_1
XFILLER_32_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07234_ _01112_ _01121_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__nand2_1
XFILLER_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07165_ _00940_ _01045_ _01046_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__nor3_1
X_07096_ _00955_ _00968_ _00970_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nor3_1
X_06116_ _05153_ _05243_ _05244_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__or3_1
X_06047_ net481 net419 net411 net488 VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__a22oi_1
Xfanout223 net225 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_1
Xfanout201 net202 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_2
XFILLER_115_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout245 net57 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_4
Xfanout256 net55 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07998_ _01918_ _01954_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__xor2_1
XFILLER_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout267 net53 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_2
Xfanout278 net52 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_2
X_09806_ _03881_ _03882_ _03926_ _03927_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__and4_1
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_4
X_06949_ net552 net403 _00687_ _00686_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__a31o_1
XFILLER_74_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09737_ _03745_ _03748_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__nor2_1
XFILLER_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09668_ _03655_ _03658_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__nand2b_1
X_08619_ _02630_ _02631_ _02633_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__a21o_1
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09599_ _03691_ _03700_ _03702_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__and3_1
XFILLER_70_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10512_ net531 net261 VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__nand2_1
XFILLER_10_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10443_ _04599_ _04618_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__and2b_1
X_10374_ net563 net262 VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__nand2_1
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08970_ _03013_ _03015_ _02995_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__a21o_1
XFILLER_114_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07921_ _01718_ _01739_ _01738_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__a21bo_1
X_07852_ _01793_ _01794_ _01792_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__o21ai_1
XFILLER_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06803_ _00649_ _00650_ _00651_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__o21ai_1
XFILLER_110_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput1 A[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_07783_ _01548_ _01552_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__nand2_1
XFILLER_37_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09522_ _03617_ _03618_ _03499_ _03503_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__o211a_1
X_06734_ _00567_ _00577_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__xor2_1
X_06665_ net520 net610 net333 net326 VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__and4_1
XFILLER_52_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09453_ net366 net556 _03540_ _03541_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__nand4_1
X_08404_ _02396_ _02397_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__xnor2_1
X_09384_ net159 net619 net304 net289 VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__nand4_2
XFILLER_24_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05616_ _02829_ _02850_ _02840_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__o21bai_1
XFILLER_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06596_ _00321_ _00323_ _00425_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__nand3_2
X_08335_ net193 net558 VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05547_ _02861_ _02872_ _02883_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__a21o_1
X_08266_ _02078_ _02080_ _02245_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_50_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05478_ _01955_ _01977_ net627 net189 VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__o211a_1
XFILLER_118_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07217_ _01101_ _01102_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__nor2_1
X_08197_ _02169_ _02170_ _02171_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__or3_1
XFILLER_4_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07148_ _01025_ _01026_ _01018_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__a21o_1
XFILLER_106_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07079_ _00948_ _00949_ _00950_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__o21a_1
XFILLER_105_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10090_ net330 net323 net537 net529 VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__and4_1
XFILLER_87_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_106_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10426_ net539 net278 net531 net270 VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_115_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10357_ net292 net524 net508 net306 VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__a22oi_1
X_10288_ _04449_ _04450_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__and2_1
XFILLER_111_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06450_ net499 net372 _00157_ _00155_ VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__a31o_1
XFILLER_61_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05401_ net479 net257 VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__nand2_1
X_06381_ _00195_ _00200_ VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_60_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08120_ _02088_ _02087_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__nand2b_1
X_05332_ _00527_ _00538_ _00516_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__o21bai_1
X_08051_ _01807_ _01842_ _01841_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__a21bo_1
X_07002_ net232 net595 net588 net237 VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__a22oi_1
XFILLER_102_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08953_ _02996_ _02997_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__and2b_1
X_07904_ _01850_ _01851_ _01744_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_71_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08884_ _02900_ _02921_ _02922_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__and3_1
X_07835_ _01762_ _01775_ _01776_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__nor3_1
XFILLER_29_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07766_ net489 net496 net281 net273 VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__and4_1
XFILLER_84_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06717_ _00550_ _00557_ _00558_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__nand3_2
XFILLER_71_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09505_ _03580_ _03598_ _03599_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__nand3_1
X_07697_ _01610_ _01625_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__nand3_2
X_09436_ net597 net312 VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__nand2_1
X_06648_ _00480_ _00482_ _00359_ _00361_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__o211a_1
XFILLER_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06579_ _00405_ _00406_ _00281_ _00284_ VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_82_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09367_ net297 net258 _03447_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_35_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08318_ net422 net579 VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__nand2_1
X_09298_ _03370_ _03372_ _03236_ _03238_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o211ai_2
X_08249_ _02059_ _02062_ _02226_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10211_ _04321_ _04366_ _04367_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__or3_2
XFILLER_79_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10142_ _04209_ net130 _04292_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_7_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10073_ _04216_ _04217_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__nor2_1
XFILLER_102_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10409_ _04452_ _04520_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__nand2_1
XFILLER_97_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05950_ _05015_ _05017_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05881_ _05004_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__and2_1
X_07620_ _01375_ _01541_ VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__and2_1
XFILLER_93_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07551_ _01313_ _01315_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__nand2_1
X_06502_ net218 net172 VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07482_ _01262_ _01264_ _01390_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_105_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06433_ _05070_ _00041_ _00250_ VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__and3b_1
X_09221_ _03288_ _03289_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__and2b_1
XFILLER_22_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06364_ _00076_ _00078_ _00077_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__o21ba_1
X_09152_ net445 net245 _03214_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_32_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08103_ _01924_ _01932_ _01931_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__a21o_1
X_05315_ net435 net487 net493 net342 VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__a22oi_2
X_06295_ _00113_ _00114_ _00106_ VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__a21o_1
X_09083_ _03004_ _03005_ _03002_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__a21bo_1
X_08034_ _01993_ _01994_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__nor2_1
XFILLER_107_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09985_ _04119_ _04120_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__and2b_1
X_08936_ _02978_ _02979_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08867_ _02902_ _02903_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__and2b_1
X_07818_ _01755_ _01756_ _01757_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__and3_1
XFILLER_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08798_ _02827_ _02828_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__nor2_1
XFILLER_57_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07749_ _01512_ _01514_ net131 _01681_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__a211o_1
XFILLER_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_636 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09419_ _03502_ _03504_ _03383_ _03387_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__o211a_1
XFILLER_40_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10125_ _04271_ _04272_ _04264_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__a21o_1
XFILLER_0_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10056_ _04094_ _04096_ _04196_ _04197_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__o211ai_1
XFILLER_75_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06080_ _05206_ _05209_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout608 net611 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__buf_2
XFILLER_98_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout619 net620 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06982_ _00838_ _00847_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__xnor2_1
X_09770_ _03887_ _03888_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__nor2_1
XFILLER_100_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08721_ _02743_ _02744_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__and2b_1
X_05933_ _04917_ _05063_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__xnor2_2
X_08652_ _02668_ _02669_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__nor2_1
X_07603_ _01364_ _01521_ _01522_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__and3_1
XFILLER_94_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05864_ _04936_ _04938_ _04995_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__a21oi_1
X_08583_ _02431_ _02433_ _02432_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__o21bai_1
X_05795_ _04926_ _04927_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__nor2_1
X_07534_ _01447_ _01448_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__and2b_1
X_07465_ net630 net264 VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_66_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06416_ _00128_ _00130_ _00233_ _00235_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__a211oi_2
XFILLER_22_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09204_ net424 net509 net504 net430 VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__a22oi_1
X_07396_ _01139_ _01141_ _01140_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_118_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06347_ _00152_ _00164_ _00166_ VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__nor3_1
X_09135_ _03022_ _03062_ _03195_ _03196_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__a211oi_2
X_06278_ _00092_ _00097_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__xnor2_1
X_09066_ _02994_ _03120_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__nor3_1
X_08017_ _01972_ _01973_ _01957_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__a21oi_1
XFILLER_89_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _03980_ _04101_ _04102_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__nand3_2
XFILLER_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08919_ _02944_ _02957_ _02959_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__or3_1
XFILLER_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09899_ _03924_ _03926_ _04026_ _04028_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__a211oi_2
XFILLER_85_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10674_ _00822_ _00876_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__nor2_1
XFILLER_43_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10108_ _04253_ _04254_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__xor2_1
XFILLER_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10039_ _04046_ _04055_ _04054_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__a21o_1
XFILLER_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05580_ net135 _02130_ _03255_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_102_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07250_ net187 net429 net166 net625 VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_42_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07181_ _01059_ _01063_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__xor2_1
X_06201_ _00020_ _00021_ _05227_ _05229_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__a211oi_1
XFILLER_117_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06132_ _05252_ _05260_ VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__nand2_1
XFILLER_117_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06063_ _05190_ _05191_ _05173_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_113_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout405 net406 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__buf_2
XFILLER_101_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout427 net428 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_2
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_2
Xfanout438 net442 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__clkbuf_2
X_09822_ _03944_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__nor2_1
Xfanout449 net32 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09753_ _03867_ _03868_ _03869_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__and3_1
XFILLER_100_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06965_ _00827_ _00828_ _00703_ _00705_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__a211oi_1
XFILLER_74_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08704_ _02723_ _02724_ _02713_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__a21oi_2
X_06896_ _00751_ _00752_ _00642_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05916_ _05028_ _05045_ _05046_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__nand3_2
X_09684_ _03793_ _03794_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08635_ net193 net533 VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nand2_1
X_05847_ _04977_ _04978_ _04919_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__a21o_1
X_08566_ _02572_ _02573_ _02411_ _02414_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__a211oi_1
XFILLER_42_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07517_ _01427_ _01428_ _01424_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__a21o_1
XFILLER_81_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05778_ _04581_ _04910_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__xnor2_2
XFILLER_35_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08497_ _02492_ _02498_ _02499_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_12_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07448_ net138 _01352_ _01195_ _01197_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__o211ai_1
XFILLER_50_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07379_ _01120_ _01122_ _01278_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__and3_1
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09118_ _03173_ _03176_ _03177_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__nand3_1
X_10390_ _04560_ _04561_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__xnor2_1
X_09049_ _03100_ _03101_ _02877_ _02879_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__a211o_1
XFILLER_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10657_ net248 net500 _04827_ _04831_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__a31o_1
X_10588_ _04727_ _04733_ _04772_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__nor3_1
XFILLER_114_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06750_ _00448_ _00457_ _00456_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__a21bo_1
X_06681_ net484 net371 _00393_ _00391_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_47_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05701_ _03821_ _03843_ _04559_ _04570_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__a211oi_4
XFILLER_36_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08420_ _02411_ _02412_ _02241_ _02243_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_47_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05632_ _03799_ _03810_ _03003_ _03091_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__o211ai_2
XFILLER_63_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08351_ _01998_ _02175_ _02339_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__or3_1
X_05563_ _03058_ _03069_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__nor2_1
X_07302_ _01131_ _01132_ _01195_ _01196_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__or4bb_4
X_08282_ net221 net340 VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__nand2_1
XFILLER_20_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05494_ _02304_ _02315_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__nor2_1
X_07233_ _01113_ _01119_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__xnor2_1
X_07164_ _01043_ _01044_ _00895_ _00897_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__o211a_1
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07095_ _00818_ _00820_ _00967_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__and3_1
X_06115_ _05243_ _05244_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__nor2_1
X_06046_ net481 net488 net418 net410 VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__and4_1
XFILLER_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout202 net62 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout213 net61 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_2
XFILLER_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout246 net247 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_4
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_2
Xfanout235 net58 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_2
XFILLER_115_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout279 net280 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_2
X_07997_ _01952_ _01953_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__nand2_1
XFILLER_86_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout257 net55 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_2
Xfanout268 net269 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_2
X_09805_ _03924_ _03925_ _03819_ _03822_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__a211o_1
X_06948_ _00663_ _00666_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__nand2_1
XFILLER_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09736_ _03849_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__xnor2_1
X_09667_ _03758_ _03774_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__xnor2_1
X_06879_ _00733_ _00734_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__nand3_2
X_08618_ net422 net564 VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__and2_1
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09598_ _03698_ _03699_ _03692_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__a21o_1
XFILLER_27_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08549_ _02430_ _02439_ _02438_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_25_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10511_ _04689_ _04690_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__nor2_1
XFILLER_7_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10442_ _04616_ _04617_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10373_ _04541_ _04542_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__nor2_1
XFILLER_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07920_ _01869_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_110_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07851_ _01792_ _01793_ _01794_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__or3_1
X_06802_ _00649_ _00650_ _00651_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__or3_1
X_07782_ _01576_ _01585_ _01583_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__a21o_1
Xinput2 A[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
XFILLER_56_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06733_ _00575_ _00576_ VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__and2b_1
X_09521_ _03615_ _03616_ _03459_ _03463_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__o211a_1
XFILLER_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06664_ _00496_ _00499_ VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__xnor2_1
XFILLER_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09452_ net366 net556 _03540_ _03541_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__a22o_1
X_08403_ net489 net246 VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__nand2_1
X_06595_ _00321_ _00323_ _00425_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__a21o_1
XFILLER_52_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09383_ net619 net312 _03289_ _03288_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__a31o_1
XFILLER_24_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05615_ _03614_ _03624_ _03603_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__o21ai_1
XFILLER_61_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08334_ _02169_ _02171_ _02170_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__o21bai_1
X_05546_ _02861_ _02872_ _02883_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_22_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08265_ _02243_ _02244_ _02233_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_50_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05477_ _01671_ _02130_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__xor2_1
X_07216_ net449 net362 net354 net455 VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__a22oi_1
X_08196_ net226 net526 net510 net238 VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__a22oi_2
XFILLER_118_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07147_ _01018_ _01025_ _01026_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__nand3_1
XFILLER_105_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07078_ _00948_ _00949_ _00950_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__nor3_1
XFILLER_106_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06029_ net522 net398 net381 net607 VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__a22oi_1
XFILLER_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09719_ _03714_ _03717_ _03831_ _03833_ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__a211oi_2
XFILLER_43_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10425_ _04535_ _04598_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__xnor2_1
X_10356_ net306 net524 _04522_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__and3_1
XFILLER_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10287_ _04374_ _04377_ _04448_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__or3_1
XFILLER_111_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05400_ net342 net471 net459 net435 VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__a22oi_2
X_06380_ _00198_ _00199_ VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_60_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05331_ _00516_ _00538_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__nor2_1
X_08050_ _01980_ _02012_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__xnor2_1
X_07001_ net237 net227 net595 net588 VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__and4_1
XFILLER_115_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08952_ net405 net556 net540 net413 VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__a22o_1
X_07903_ _01744_ _01850_ _01851_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_71_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08883_ _02919_ _02920_ _02901_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__a21o_1
XFILLER_96_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07834_ _01772_ _01773_ _01774_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__a21oi_1
X_07765_ _01604_ _01607_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__or2_1
XFILLER_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07696_ _01623_ _01624_ _01615_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__a21o_1
X_06716_ _00554_ _00555_ _00556_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__a21o_1
XFILLER_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09504_ _03596_ _03597_ _03478_ _03480_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__o211ai_1
X_06647_ _00359_ _00361_ _00480_ _00482_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__a211oi_2
XFILLER_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09435_ _03521_ _03522_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__and2b_1
XFILLER_40_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06578_ _00281_ _00284_ _00405_ _00406_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_82_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09366_ net176 net274 net265 net219 VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_35_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08317_ _02299_ _02302_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__xnor2_1
X_09297_ _03236_ _03238_ _03370_ _03372_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__a211o_1
X_05529_ net517 net196 VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__nand2_1
X_08248_ _02059_ _02062_ _02226_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__and3_1
XFILLER_106_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08179_ _01970_ _01972_ _02150_ _02152_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__a211oi_2
X_10210_ net136 _04365_ _04281_ _04283_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__o211a_1
XFILLER_106_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10141_ _04287_ _04290_ _04245_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_7_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10072_ _04214_ _04215_ _04110_ _04115_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__o211a_1
XFILLER_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10408_ _04449_ _04518_ _04519_ VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__a21o_1
X_10339_ _04459_ _04463_ _04504_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05880_ _05009_ _05010_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__xnor2_1
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07550_ _01465_ _01466_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__nand2_1
XFILLER_53_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06501_ _00313_ _00322_ VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_52_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07481_ _01262_ _01264_ _01390_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_105_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09220_ net597 net328 net320 net612 VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__a22o_1
XFILLER_61_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06432_ _00038_ _00040_ _00142_ _00251_ VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__a31o_1
X_06363_ _00179_ _00182_ VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__xnor2_1
X_09151_ net445 net242 VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08102_ _02067_ _02068_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__xnor2_1
X_05314_ net257 net516 VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__nand2_1
X_09082_ net424 net525 _03136_ _03137_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nand4_2
X_06294_ _00106_ _00113_ _00114_ VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__nand3_1
X_08033_ net226 net534 net526 net238 VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__a22oi_1
Xinput60 B[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
XFILLER_88_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09984_ _04120_ _04119_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__and2b_1
X_08935_ _02976_ _02977_ _02847_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08866_ net406 net565 net557 net414 VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__a22o_1
X_07817_ _01577_ _01579_ _01578_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__o21bai_1
X_08797_ _02740_ _02742_ _02825_ _02826_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__o22a_1
X_07748_ _01512_ _01514_ net131 _01681_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_84_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07679_ _01604_ _01605_ _01436_ _01438_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__o211a_1
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09418_ _03383_ _03387_ _03502_ _03504_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__a211oi_2
X_09349_ _03421_ _03427_ _03429_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__nand3_1
XFILLER_21_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10124_ _04264_ _04271_ _04272_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__nand3_1
XFILLER_0_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10055_ _04094_ _04096_ _04196_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__o211a_1
XFILLER_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout609 net611 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_100_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06981_ _00838_ _00847_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__and2_1
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08720_ net170 net329 net321 net178 VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__a22o_1
X_05932_ _04977_ _05060_ _05062_ _04917_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__a211oi_1
X_08651_ _02620_ _02622_ _02666_ _02667_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__o22a_1
X_05863_ _04992_ _04993_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__xnor2_1
X_07602_ _01521_ _01522_ _01364_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__a21o_1
XFILLER_66_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08582_ _02589_ _02590_ _02591_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__nand3_1
XFILLER_54_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05794_ net480 net192 net431 net488 VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__a22oi_1
X_07533_ net407 net174 net166 net415 VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__a22o_1
XFILLER_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07464_ _01370_ _01371_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_66_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06415_ _00172_ _00173_ _00231_ _00232_ VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_10_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ net430 net424 net509 net504 VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__and4_1
X_07395_ _01293_ _01296_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__xnor2_1
X_09134_ _03193_ _03194_ _03154_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_118_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06346_ _00058_ _00060_ _00163_ VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__and3_1
X_06277_ _00092_ _00097_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__nand2b_1
X_09065_ _03117_ _03118_ _03119_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__o21a_1
X_08016_ _01957_ _01972_ _01973_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__nand3_1
XFILLER_104_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_244 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09967_ _04099_ _04100_ _04080_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__a21o_1
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08918_ _02944_ _02957_ _02959_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__nor3_1
XFILLER_85_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09898_ _04024_ _04025_ _03883_ _03928_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__a211oi_1
XFILLER_85_695 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08849_ _02880_ _02881_ _02725_ _02727_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__a211o_1
XFILLER_27_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10673_ _00876_ _04859_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__nor2_1
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10107_ net599 net249 VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nand2_1
XFILLER_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10038_ _04176_ _04177_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__xor2_1
XFILLER_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06200_ _05227_ _05229_ _00020_ _00021_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_42_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07180_ _01059_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__nor2_1
X_06131_ _05253_ _05258_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__xnor2_1
X_06062_ _05173_ _05190_ _05191_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_113_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout417 net421 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__buf_2
XFILLER_86_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout428 net429 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__buf_2
X_09821_ _03836_ _03838_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__and2b_1
Xfanout406 net37 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__buf_2
Xfanout439 net442 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__buf_2
XFILLER_113_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09752_ _03765_ _03767_ _03764_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__a21bo_1
X_06964_ _00703_ _00705_ _00827_ _00828_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__o211a_1
X_08703_ _02713_ _02723_ _02724_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__and3_2
X_06895_ _00642_ _00751_ _00752_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__or3_1
XFILLER_73_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05915_ _05028_ _05045_ _05046_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__and3_1
X_09683_ net176 net248 VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__and2_1
XFILLER_66_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08634_ net198 net527 net511 net210 VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__a22o_1
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05846_ _04919_ _04977_ _04978_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nand3_1
X_08565_ _02411_ _02414_ _02572_ _02573_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__o211a_1
X_05777_ _04581_ _04910_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__nand2_1
X_07516_ _01424_ _01427_ _01428_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__nand3_1
XFILLER_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08496_ _02496_ _02497_ _02493_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__a21o_1
XFILLER_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07447_ _01195_ _01197_ net138 _01352_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__a211o_1
XFILLER_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07378_ _01120_ _01122_ _01278_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__a21oi_1
XFILLER_10_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06329_ _00147_ _00148_ VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09117_ net366 net579 _03174_ _03175_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nand4_1
XFILLER_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09048_ _02877_ _02879_ _03100_ _03101_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__o211ai_2
XFILLER_2_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10656_ _04844_ _04845_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__xnor2_1
X_10587_ _04688_ _04770_ _04771_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__o21a_1
XFILLER_114_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06680_ _00517_ _00518_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__or2_1
XFILLER_48_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05700_ _03395_ _04548_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__nor2_1
X_05631_ _03003_ _03091_ _03799_ _03810_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__a211o_2
XFILLER_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08350_ _01998_ _02175_ _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__o21a_1
XFILLER_24_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07301_ _01193_ _01194_ _01036_ _01038_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_63_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05562_ _02249_ _02282_ _03047_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__and3_1
XFILLER_32_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08281_ _02262_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__xnor2_1
X_05493_ net479 net229 net471 net235 VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07232_ _01113_ _01119_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__nand2b_1
XFILLER_118_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07163_ _00895_ _00897_ _01043_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__a211oi_2
XFILLER_118_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06114_ _05241_ _05242_ _05148_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07094_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__inv_2
X_06045_ net495 net403 VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__nand2_1
XFILLER_99_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_2
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
Xfanout225 net6 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
Xfanout247 net57 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout236 net238 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_2
X_09804_ _03819_ _03822_ _03924_ _03925_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__o211ai_4
XFILLER_115_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07996_ _01950_ _01951_ _01803_ _01805_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__o211ai_1
XFILLER_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout269 net270 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_1
Xfanout258 net260 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_2
X_06947_ _00799_ _00809_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__xnor2_1
XFILLER_46_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09735_ net368 net528 VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__nand2_1
X_09666_ _03758_ _03774_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__nor2_1
X_06878_ _00584_ _00592_ _00591_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__a21bo_1
X_08617_ net428 net557 net542 net186 VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__a22o_1
XFILLER_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09597_ _03692_ _03698_ _03699_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__nand3_2
X_05829_ _04959_ _04960_ _04961_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__nand3_1
X_08548_ _02553_ _02554_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08479_ _02476_ _02477_ _02478_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__a21o_1
XFILLER_23_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10510_ net270 net523 net507 net278 VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__a22oi_1
XFILLER_10_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10441_ net570 net244 VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__nand2_1
X_10372_ net546 net277 net268 net561 VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__a22oi_1
XFILLER_104_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10639_ net248 net500 _04827_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__a21oi_1
XFILLER_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_110_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07850_ net427 net594 net585 net184 VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__a22oi_2
X_06801_ net492 net339 VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__nand2_1
X_07781_ _01716_ _01717_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput3 A[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_4
XFILLER_83_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06732_ _00573_ _00574_ _00568_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__a21o_1
XFILLER_49_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09520_ _03459_ _03463_ _03615_ _03616_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__a211oi_2
XFILLER_64_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06663_ _00496_ _00499_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__and2_1
XFILLER_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09451_ net374 net540 net532 net391 VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__a22o_1
XFILLER_37_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08402_ _02394_ _02395_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__nor2_1
X_06594_ _00414_ _00423_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__xnor2_1
X_09382_ _03351_ _03355_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05614_ _03603_ _03614_ _03624_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__or3_1
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08333_ _02159_ _02161_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__nand2_1
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05545_ _02359_ _02380_ _02370_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__o21bai_1
X_08264_ _02233_ _02243_ _02244_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_22_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05476_ _01682_ _02119_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__xnor2_2
X_07215_ net455 net449 net362 net354 VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__and4_1
X_08195_ net238 net226 net526 net510 VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__and4_1
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07146_ _01022_ _01023_ _01024_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__a21o_1
X_07077_ _00801_ _00803_ _00802_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__o21ba_1
XFILLER_106_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06028_ net518 net607 net398 net381 VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07979_ _01924_ _01934_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__xnor2_1
X_09718_ _03829_ _03830_ _03670_ _03720_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__o211a_1
XFILLER_28_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09649_ _03754_ _03756_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10424_ _04596_ _04597_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10355_ net291 net508 VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__nand2_1
XFILLER_78_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10286_ _04374_ _04377_ _04448_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_29_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_1_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05330_ net436 net493 net516 net343 VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07000_ net216 net603 VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__nand2_1
XFILLER_115_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08951_ net413 net405 net556 net540 VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_47_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07902_ _01848_ _01849_ _01673_ _01676_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_71_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08882_ _02901_ _02919_ _02920_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__nand3_2
XFILLER_111_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07833_ _01772_ _01773_ _01774_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__and3_1
XFILLER_69_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07764_ _01563_ _01565_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__nand2b_1
XFILLER_112_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07695_ _01615_ _01623_ _01624_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__nand3_1
X_06715_ _00554_ _00555_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__nand3_2
X_09503_ _03478_ _03480_ _03596_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__a211o_1
X_06646_ _00478_ _00479_ _00375_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_56_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09434_ net328 net584 net320 net590 VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__a22o_1
XFILLER_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06577_ _00403_ _00404_ _00308_ _00311_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_82_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09365_ net219 net176 net274 net265 VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_35_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08316_ _02300_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__and2b_1
X_09296_ _03368_ _03369_ _03191_ _03193_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__o211a_1
X_05528_ _02676_ _02687_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nor2_1
X_08247_ _02223_ _02224_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05459_ _01922_ _01933_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08178_ _02148_ _02149_ _02134_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_65_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07129_ _01003_ _01007_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10140_ _04245_ _04287_ _04290_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_7_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10071_ _04110_ _04115_ _04214_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__a211oi_1
XFILLER_75_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_74_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10407_ _04577_ _04579_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__nor2_1
XFILLER_112_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10338_ _04459_ _04463_ _04504_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__and3_1
XFILLER_78_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10269_ _04428_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__or2_1
XFILLER_66_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07480_ _01379_ _01388_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__xnor2_1
X_06500_ _00313_ _00322_ VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_52_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06431_ _00034_ _00036_ _00141_ VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__o21a_1
XFILLER_21_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06362_ _00180_ _00181_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__nor2_1
X_09150_ _03212_ _03213_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_32_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08101_ net519 net246 VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__nand2_1
X_06293_ _00110_ _00111_ _00112_ VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__a21o_1
X_05313_ net435 net342 net487 net493 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__and4_1
XFILLER_30_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09081_ net424 net525 _03136_ _03137_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__a22o_1
X_08032_ net238 net226 net533 net526 VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__and4_1
Xinput50 B[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xinput61 B[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
XFILLER_89_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09983_ _03992_ _03993_ _03997_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__o21a_1
XFILLER_88_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08934_ _02847_ _02976_ _02977_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__or3_1
XFILLER_88_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08865_ net414 net406 net565 net557 VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__and4_1
X_07816_ _01753_ _01754_ _01752_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08796_ _02740_ _02742_ _02825_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__nor4_1
X_07747_ _01569_ _01570_ _01678_ _01679_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__o22a_1
XFILLER_84_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07678_ _01436_ _01438_ _01604_ _01605_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06629_ _00443_ _00461_ _00463_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__and3_1
X_09417_ _03499_ _03500_ _03501_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09348_ _03425_ _03426_ _03422_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__a21o_1
XFILLER_40_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09279_ net176 net282 _03351_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__a22o_1
XFILLER_32_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10123_ _04269_ _04270_ _04265_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__a21o_1
XFILLER_88_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10054_ _04193_ _04194_ _04089_ _04091_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_82_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_91_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06980_ _00843_ _00845_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__xor2_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05931_ _05060_ _05061_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__xnor2_1
X_08650_ _02620_ _02622_ _02666_ _02667_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__nor4_1
X_05862_ _04992_ _04993_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__nor2_1
X_07601_ _01521_ _01522_ _01364_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08581_ _02589_ _02590_ _02591_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__a21o_1
X_05793_ net480 net488 net192 net431 VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__and4_1
X_07532_ net415 net407 net174 net166 VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__and4_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07463_ net522 net281 net273 net608 VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_66_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06414_ _00172_ _00173_ _00231_ _00232_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__or4bb_1
X_09202_ _03257_ _03268_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__nor2_1
XFILLER_22_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07394_ _01294_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__and2b_1
X_09133_ _03154_ _03193_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_118_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06345_ _00164_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_118_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06276_ _00093_ _00096_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__xnor2_1
X_09064_ _03117_ _03118_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__nor3_2
X_08015_ _01957_ _01972_ _01973_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__and3_1
XFILLER_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09966_ _04080_ _04099_ _04100_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_90_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08917_ _02954_ _02955_ _02956_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__a21oi_1
X_09897_ _03883_ _03928_ _04024_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__o211a_1
XFILLER_85_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08848_ _02882_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__inv_2
XFILLER_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08779_ _02805_ _02806_ _02808_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__nand3_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10672_ _00844_ _00865_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__nor2_1
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10106_ _04251_ _04252_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nor2_1
XFILLER_0_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10037_ _04176_ _04177_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__or2_1
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06130_ _05253_ _05258_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__nand2b_1
X_06061_ _05188_ _05189_ _05174_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_113_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout407 net408 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
Xfanout429 net430 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_2
Xfanout418 net421 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_2
X_09820_ _03942_ _03943_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__nand2_1
XFILLER_98_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06963_ _00824_ _00826_ _00810_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__o21ai_1
X_09751_ net336 net558 _03865_ _03866_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__nand4_1
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08702_ _02721_ _02722_ _02714_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__a21o_1
X_05914_ _05042_ _05043_ _05044_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__a21o_1
X_06894_ _00642_ _00751_ _00752_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__nor3_1
XFILLER_94_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09682_ _03790_ _03791_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__xnor2_1
XFILLER_27_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08633_ net210 net198 net527 net511 VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__nand4_1
X_05845_ _04974_ _04976_ _04897_ _04899_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__o211ai_1
X_08564_ _02569_ _02570_ _02407_ _02409_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__o211ai_1
X_05776_ _04907_ _04909_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__nor2_1
XFILLER_42_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07515_ net388 net370 _01425_ _01426_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__nand4_1
X_08495_ _02493_ _02496_ _02497_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__nand3_1
X_07446_ _01195_ _01197_ net138 _01352_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__a211oi_1
XFILLER_50_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07377_ _01267_ _01276_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__xnor2_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06328_ net631 net339 VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__nand2_1
X_09116_ net366 net579 _03174_ _03175_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__a22o_1
X_09047_ _03097_ _03098_ _02873_ _02875_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_92_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06259_ _00076_ _00079_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09949_ _04002_ _04006_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__nand2_1
XFILLER_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10655_ _04815_ _04823_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__nor2_1
XFILLER_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10586_ net259 net507 net501 net266 VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__a22o_1
XFILLER_5_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05630_ _03777_ _03788_ _03417_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__a21oi_1
XFILLER_64_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07300_ _01036_ _01038_ _01193_ _01194_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_63_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05561_ _02249_ _02282_ _03047_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__a21oi_1
X_08280_ net464 net316 VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__nand2_1
X_05492_ net479 net235 net229 net471 VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__and4_1
X_07231_ _01114_ _01118_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__xnor2_1
XFILLER_118_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07162_ _00977_ _00978_ _01041_ _01042_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__o22a_1
XFILLER_118_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06113_ _05148_ _05241_ _05242_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__and3_1
XFILLER_8_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07093_ _00818_ _00820_ _00967_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__a21oi_1
X_06044_ _05105_ _05112_ _05111_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__a21o_1
Xfanout204 net205 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_2
XFILLER_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_1
Xfanout215 net218 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_2
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_2
X_09803_ _03922_ _03923_ _03779_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__a21o_1
X_07995_ _01803_ _01805_ _01950_ _01951_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__a211o_1
Xfanout248 net253 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_4
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_1
X_06946_ _00807_ _00808_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__and2b_1
XFILLER_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09734_ _03847_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__and2b_1
XFILLER_82_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06877_ _00731_ _00732_ _00723_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__a21o_1
XFILLER_27_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09665_ _03763_ _03773_ VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08616_ net186 net428 net557 net542 VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__nand4_1
X_05828_ _04881_ _04883_ _04882_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__o21bai_1
X_09596_ _03696_ _03697_ _03693_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__a21o_1
X_08547_ net482 net246 VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__nand2_1
XFILLER_70_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05759_ _04889_ _04890_ _04891_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__a21o_1
X_08478_ _02476_ _02477_ _02478_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__nand3_1
XFILLER_24_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07429_ _01330_ _01331_ _01332_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__a21o_1
XFILLER_10_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10440_ _04614_ _04615_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__nor2_1
XFILLER_40_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10371_ net561 net546 net276 net268 VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__and4_1
XFILLER_49_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10638_ _04688_ _04803_ _04770_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a21oi_1
X_10569_ _04714_ _04753_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06800_ net477 net364 net356 net485 VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__a22oi_2
XFILLER_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07780_ net630 net247 VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__nand2_1
Xinput4 A[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
XFILLER_83_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06731_ _00568_ _00573_ _00574_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__and3_1
XFILLER_36_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09450_ net391 net374 net540 net532 VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__nand4_1
XFILLER_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08401_ _02222_ _02225_ _02393_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__a21oi_1
X_06662_ _00497_ _00498_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__and2_1
XFILLER_52_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06593_ _00414_ _00423_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__and2_1
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09381_ _03292_ _03301_ _03300_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__a21o_1
X_05613_ net343 net550 net467 net436 VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__a22oi_2
X_08332_ _02318_ _02319_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__and2_1
X_05544_ _02840_ _02850_ _02829_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__o21ai_1
X_08263_ _02241_ _02242_ _02234_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__a21o_1
XFILLER_60_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07214_ net462 net340 VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__nand2_1
X_05475_ _02097_ _02108_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__nand2b_1
X_08194_ net214 net534 VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07145_ _01022_ _01023_ _01024_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__nand3_1
X_07076_ net477 net341 _00946_ _00947_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__o2bb2a_1
X_06027_ net518 net404 _05086_ _05085_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__a31o_1
XFILLER_87_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07978_ _01931_ _01932_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__and2b_1
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06929_ _00681_ _00683_ _00788_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__o21a_1
X_09717_ _03670_ _03720_ _03829_ _03830_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_87_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09648_ _03650_ _03652_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__nand2_1
XFILLER_35_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09579_ net219 net248 VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__nand2_1
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10423_ _04594_ _04595_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__and2_1
XFILLER_109_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10354_ net291 net508 VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__and2_1
XFILLER_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10285_ _04445_ _04446_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout590 net592 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__buf_2
XFILLER_93_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_102_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08950_ _02914_ _02917_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__nand2_1
X_07901_ _01673_ _01676_ _01848_ _01849_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__a211o_1
XFILLER_96_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08881_ _02917_ _02918_ _02790_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__a21o_1
XFILLER_111_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07832_ _01588_ _01596_ _01594_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__a21bo_1
XFILLER_111_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07763_ _01567_ _01569_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__or2_1
X_09502_ _03594_ _03595_ _03473_ _03475_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__o211a_1
X_06714_ net470 net426 _00416_ _00415_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__a31o_1
X_07694_ _01620_ _01621_ _01622_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__a21o_1
X_06645_ _00375_ _00478_ _00479_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__nand3_1
X_09433_ net590 net328 net584 net320 VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__and4_1
XFILLER_24_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09364_ _03327_ _03443_ _03444_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__nor3_1
XFILLER_40_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06576_ _00308_ _00311_ _00403_ _00404_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_82_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08315_ net407 net593 net585 net415 VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_35_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_20 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05527_ net486 net206 net201 net494 VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__a22oi_1
X_09295_ _03191_ _03193_ _03368_ _03369_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__a211o_1
X_08246_ net489 net251 _02223_ VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__nand3_1
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05458_ net627 net196 VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__nand2_1
XFILLER_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08177_ _02134_ _02148_ _02149_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__and3_1
X_07128_ _01004_ _01005_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__nor2_1
X_05389_ net627 net206 _01159_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__and3_1
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07059_ _00918_ _00929_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_7_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10070_ _04211_ _04213_ _04104_ _04106_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10406_ _04575_ _04576_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__and2_1
XFILLER_97_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10337_ _04501_ _04502_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10268_ _04408_ _04409_ _04427_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__and3_1
X_10199_ _04351_ _04352_ _04339_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__a21oi_1
XFILLER_19_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06430_ _00038_ _00142_ VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__and2_1
XFILLER_34_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06361_ net552 net433 net469 net192 VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__a22oi_1
XFILLER_21_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08100_ _02065_ _02066_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__nor2_1
X_06292_ _00110_ _00111_ _00112_ VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__nand3_1
X_05312_ _00298_ _00309_ _00320_ VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__a21o_1
X_09080_ net430 net510 net504 net188 VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__a22o_1
X_08031_ net214 net541 VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__nand2_1
XFILLER_30_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput40 B[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
Xinput51 B[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_2
Xinput62 B[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09982_ _04116_ _04117_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__xnor2_1
X_08933_ _02974_ _02975_ _02825_ net134 VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__a211oi_1
XFILLER_97_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08864_ _02809_ _02811_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__nand2_1
X_07815_ _01752_ _01753_ _01754_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__or3_1
XFILLER_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08795_ _02823_ _02824_ _02666_ net145 VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__a211oi_1
XFILLER_29_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07746_ _01569_ _01570_ _01678_ _01679_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__nor4_2
XFILLER_44_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07677_ _01602_ _01603_ _01462_ _01465_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__o211a_1
XFILLER_80_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09416_ _03499_ _03500_ _03501_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__nand3_1
X_06628_ _00458_ _00459_ _00460_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__a21o_1
X_06559_ _00376_ _00377_ _00384_ _00386_ VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__nand4_2
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09347_ _03422_ _03425_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__nand3_1
X_09278_ net159 net304 net289 net168 VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__a22o_1
XFILLER_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08229_ _02028_ _02030_ _02204_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__and3_1
XFILLER_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10122_ _04265_ _04269_ _04270_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__nand3_2
XFILLER_0_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10053_ _04089_ _04091_ _04193_ _04194_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__a211o_1
XFILLER_48_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05930_ _04977_ _04979_ _05058_ _05059_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__a211oi_2
XFILLER_94_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05861_ net628 net398 VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__nand2_1
X_07600_ _01518_ _01520_ _01360_ _01362_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__o211ai_2
X_08580_ net170 net340 VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__and2_1
XFILLER_66_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07531_ net402 net182 VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__nand2_1
XFILLER_19_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05792_ _04923_ _04924_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07462_ net522 net608 net281 net273 VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_66_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07393_ net429 net625 net618 net185 VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__a22o_1
X_06413_ _00172_ _00173_ _00231_ _00232_ VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__and4bb_1
X_09201_ _03268_ _03269_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__nor2_1
X_06344_ _00058_ _00060_ _00163_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__a21oi_2
X_09132_ _03191_ _03192_ _03052_ _03054_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_118_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09063_ _02847_ _02977_ _02976_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__o21ba_1
X_06275_ _00094_ _00095_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__nor2_1
XFILLER_116_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08014_ _01970_ _01971_ _01962_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__a21o_1
XFILLER_89_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09965_ _04097_ _04098_ _04011_ _04013_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__a211o_1
XFILLER_103_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08916_ _02957_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__inv_2
X_09896_ _04022_ _04023_ _03982_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__o21ai_1
XFILLER_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08847_ _02725_ _02727_ _02880_ _02881_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__o211ai_4
XFILLER_45_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08778_ _02631_ _02633_ _02630_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__a21bo_1
X_07729_ _01658_ _01659_ _01661_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__and3_1
XFILLER_43_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10671_ _00865_ _04858_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__nor2_1
XFILLER_107_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10105_ _04164_ _04167_ _04250_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__o21a_1
XFILLER_102_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10036_ net626 net243 VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__nand2_1
XFILLER_75_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_102_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06060_ _05174_ _05188_ _05189_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_113_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout419 net421 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__clkbuf_2
Xfanout408 net409 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_2
XFILLER_98_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06962_ _00810_ _00824_ _00826_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__or3_2
X_09750_ net336 net558 _03865_ _03866_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a22o_1
X_08701_ _02714_ _02721_ _02722_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__nand3_2
X_05913_ _05042_ _05043_ _05044_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__nand3_4
X_09681_ _03791_ _03790_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__and2b_1
XFILLER_39_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06893_ net140 _00750_ _00608_ _00611_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_68_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08632_ net198 net512 VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__nand2_1
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05844_ _04897_ _04899_ _04974_ _04976_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__a211o_1
X_08563_ _02407_ _02409_ _02569_ _02570_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__a211o_1
X_05775_ _04904_ _04905_ _04906_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__o21ba_1
X_07514_ net388 net370 _01425_ _01426_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__a22o_1
X_08494_ net193 net542 _02494_ _02495_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__nand4_1
XFILLER_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07445_ _01285_ _01286_ _01349_ _01350_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__o22a_1
XFILLER_62_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07376_ _01267_ _01276_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__nand2_1
X_06327_ _00048_ _00146_ _00145_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__a21oi_1
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09115_ net374 net572 net565 net391 VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_79_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06258_ _00077_ _00078_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__nor2_1
X_09046_ _02873_ _02875_ _03097_ _03098_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_92_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06189_ _05210_ _05218_ _05217_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__a21bo_1
XFILLER_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09948_ _03966_ _03974_ _03972_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__a21o_1
XFILLER_18_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09879_ _04001_ _04004_ _04006_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__nand3_2
XFILLER_73_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10654_ _04842_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__nor2_1
X_10585_ net259 net500 VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__nand2_1
XFILLER_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10019_ _03954_ _03955_ _04040_ _04060_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_47_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05560_ _03025_ _03036_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__or2_1
XFILLER_63_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05491_ _02260_ _02271_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__xnor2_1
X_07230_ _01116_ _01117_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__nor2_1
XFILLER_32_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07161_ _00977_ _00978_ _01041_ _01042_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__nor4_2
XFILLER_117_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06112_ _05239_ _05240_ _05144_ _05146_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__o211ai_1
XFILLER_118_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07092_ _00956_ _00965_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__xnor2_1
X_06043_ _05096_ _05098_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__nand2_1
XFILLER_113_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout205 net62 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout216 net218 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout227 net233 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_2
Xfanout238 net58 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
X_09802_ _03779_ _03922_ _03923_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__nand3_2
X_07994_ _01948_ _01949_ _01935_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__o21a_1
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_2
X_06945_ _00804_ _00805_ _00806_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__a21o_1
X_09733_ net395 net505 _03742_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__a21o_1
X_06876_ _00723_ _00731_ _00732_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__nand3_1
X_09664_ _03771_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__and2b_1
XFILLER_82_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08615_ _02627_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__xnor2_1
X_09595_ _03693_ _03696_ _03697_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__nand3_2
XFILLER_27_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05827_ _04957_ _04958_ _04956_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08546_ _02551_ _02552_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__nor2_1
X_05758_ _04889_ _04890_ _04891_ VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__nand3_2
X_08477_ _02305_ _02307_ _02306_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__o21bai_1
X_05689_ _04407_ _04418_ _04429_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__a21o_1
X_07428_ _01330_ _01331_ _01332_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__nand3_1
XFILLER_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07359_ _01256_ _01258_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__nor2_1
X_10370_ _04538_ _04539_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__nor2_1
X_09029_ net456 net246 VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__nand2_1
XFILLER_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10637_ _04785_ _04811_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10568_ _04751_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__inv_2
X_10499_ _04676_ _04677_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__and2_1
XFILLER_107_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput5 A[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
X_06730_ _00569_ _00570_ _00572_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__o21ai_1
XFILLER_49_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06661_ _00377_ _00384_ _00387_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__nand3_1
XFILLER_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08400_ _02222_ _02225_ _02393_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__and3_1
X_05612_ net436 net343 net550 net467 VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__and4_1
XFILLER_101_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06592_ _00420_ _00421_ VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__xnor2_1
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09380_ _03460_ _03462_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__xor2_1
X_08331_ _02316_ _02317_ _02297_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__a21o_1
XFILLER_51_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05543_ _02829_ _02840_ _02850_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__or3_1
X_08262_ _02234_ _02241_ _02242_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__nand3_2
XFILLER_60_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05474_ _02075_ _02086_ _01617_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_22_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07213_ _01097_ _01098_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__nor2_1
XFILLER_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08193_ net256 net503 _01650_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_76_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07144_ _00873_ _00875_ _00874_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__a21bo_1
XFILLER_118_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07075_ _00946_ _00947_ net477 net341 VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__and4bb_1
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06026_ _05071_ _05148_ _05149_ _05155_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__o31a_1
XFILLER_87_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07977_ _01928_ _01929_ _01930_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__a21o_1
XFILLER_101_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06928_ _00681_ _00683_ _00788_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__nor3_1
XFILLER_74_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09716_ _03827_ _03828_ _03784_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_87_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06859_ _00708_ _00714_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__nand2b_1
XFILLER_55_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09647_ _03752_ _03753_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__or2_1
XFILLER_42_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09578_ _03676_ _03677_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__xnor2_1
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08529_ _02533_ _02535_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__xor2_1
XFILLER_30_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10422_ _04594_ _04595_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__nor2_1
X_10353_ _04520_ _04521_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__xor2_1
X_10284_ _04445_ _04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__nand2b_1
XFILLER_78_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout580 net582 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__buf_2
Xfanout591 net592 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_57_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07900_ _01845_ _01847_ _01783_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_71_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08880_ _02790_ _02917_ _02918_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__nand3_2
XFILLER_111_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07831_ _01770_ _01771_ _01763_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__a21o_1
XFILLER_57_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07762_ _01692_ _01697_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__xor2_1
XFILLER_84_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09501_ _03473_ _03475_ _03594_ _03595_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__a211oi_2
X_07693_ _01620_ _01621_ _01622_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__nand3_1
X_06713_ _00551_ _00552_ _00553_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__o21ai_1
X_06644_ _00375_ _00478_ _00479_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__and3_1
XFILLER_24_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09432_ _03518_ _03519_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__nor2_1
XFILLER_37_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06575_ _00387_ _00388_ _00401_ _00402_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__a22o_1
XFILLER_24_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09363_ _03443_ _03444_ _03327_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__o21a_1
X_08314_ net415 net407 net593 net585 VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__and4_1
X_05526_ net486 net494 net206 net201 VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__and4_1
XFILLER_33_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_21 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09294_ _03191_ _03193_ _03368_ _03369_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__a211oi_1
XANTENNA_10 net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08245_ net489 net251 VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__nand2_1
X_05457_ _01900_ _01911_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__nor2_1
X_08176_ _02146_ _02147_ _02139_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__a21o_1
X_05388_ net629 net206 VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__nand2_1
X_07127_ net200 net618 net602 net209 VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__a22oi_1
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07058_ _00918_ _00929_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__nor2_1
XFILLER_99_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06009_ _05050_ _05053_ _05138_ _05139_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_7_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10405_ _04575_ _04576_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__or2_1
XFILLER_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10336_ _04502_ _04501_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__nand2b_1
XFILLER_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10267_ _04408_ _04409_ _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__a21oi_1
X_10198_ _04339_ _04351_ _04352_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__and3_1
XFILLER_19_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06360_ net552 net191 net432 net469 VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_32_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06291_ _00001_ _00003_ _00002_ VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__o21bai_1
X_05311_ _00298_ _00309_ _00320_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__nand3_1
Xinput30 A[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_08030_ _01981_ _01990_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput52 B[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_4
Xinput41 B[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
Xinput63 B[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
X_09981_ _04117_ _04116_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__and2b_1
X_08932_ _02825_ net134 _02974_ _02975_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_4_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08863_ _02898_ _02899_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__nor2_1
X_07814_ net298 net362 net354 net384 VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a22oi_2
XFILLER_84_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08794_ _02666_ net145 _02823_ _02824_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__o211a_1
XFILLER_57_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07745_ _01675_ _01677_ _01507_ _01510_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__o211a_1
XFILLER_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07676_ _01462_ _01465_ _01602_ _01603_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__a211oi_2
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09415_ _03499_ _03500_ _03501_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__and3_1
XFILLER_16_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06627_ _00458_ _00459_ _00460_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_51_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06558_ _00382_ _00383_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__or2_1
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09346_ net366 net562 _03423_ _03424_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__nand4_1
X_06489_ _00185_ _00187_ _00307_ _00310_ VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__o211a_1
X_09277_ net168 net159 net304 net289 VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__nand4_2
X_05509_ _02446_ _02457_ _02468_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__a21o_1
XFILLER_21_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08228_ _02205_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__inv_2
XFILLER_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08159_ _02129_ _02131_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__nand2_1
XFILLER_79_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10121_ net574 net285 _04267_ _04268_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__nand4_2
XFILLER_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10052_ _04089_ _04091_ _04193_ _04194_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__a211oi_2
XFILLER_88_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10319_ _04482_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__nor2_1
XFILLER_3_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05860_ _04922_ _04924_ _04921_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__o21ba_1
XFILLER_93_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05791_ net628 net404 VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__nand2_1
XFILLER_66_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07530_ _01309_ _01318_ _01317_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__a21o_1
XFILLER_19_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07461_ _01217_ _01369_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_66_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07392_ net185 net429 net625 net618 VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__and4_1
X_06412_ _00229_ _00230_ _00123_ _00125_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__a211o_1
X_09200_ _03259_ _03265_ _03267_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__and3_1
X_06343_ _00153_ _00161_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__xnor2_1
X_09131_ _03052_ _03054_ _03191_ _03192_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__o211ai_4
X_09062_ _03115_ _03116_ _02889_ _02891_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_118_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06274_ net203 net387 net303 net212 VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08013_ _01962_ _01970_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__nand3_2
XFILLER_89_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09964_ _04011_ _04013_ _04097_ _04098_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_90_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08915_ _02954_ _02955_ _02956_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__and3_1
X_09895_ _03982_ _04022_ _04023_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__or3_2
X_08846_ _02877_ _02878_ _02721_ _02723_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__o211ai_2
XFILLER_57_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08777_ _02802_ _02803_ _02804_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__nand3_1
X_05989_ net254 net224 VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__nand2_1
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07728_ _01484_ _01493_ _01492_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__a21bo_1
X_07659_ _01583_ _01585_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__and2b_1
XFILLER_53_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10670_ net442 net606 net629 net349 VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__a22oi_1
X_09329_ net612 net312 VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__nand2_1
XFILLER_107_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10104_ _04164_ _04167_ _04250_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__nor3_1
X_10035_ _04174_ _04175_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__xnor2_1
XFILLER_91_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout409 net37 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_2
XFILLER_3_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06961_ _00820_ _00821_ _00823_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__a21oi_1
XFILLER_79_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08700_ _02718_ _02720_ _02715_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__a21o_1
X_09680_ _03672_ _03675_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__nor2_1
XFILLER_39_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05912_ _04955_ _04963_ _04962_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__a21bo_1
XFILLER_104_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06892_ _00608_ _00611_ net140 _00750_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_68_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08631_ net198 net512 VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__and2_1
XFILLER_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05843_ _04938_ _04939_ _04972_ _04973_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__a22oi_1
X_08562_ _02407_ _02409_ _02569_ _02570_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__a211oi_1
XFILLER_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05774_ _04907_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__inv_2
X_07513_ net222 net394 net378 net302 VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__a22o_1
X_08493_ net193 net541 _02494_ _02495_ VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__a22o_1
X_07444_ _01285_ _01286_ _01349_ _01350_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__nor4_1
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07375_ _01269_ _01274_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06326_ net521 net365 VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__nand2_1
X_09114_ net391 net374 net572 net565 VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__nand4_1
XFILLER_108_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06257_ net552 net190 net433 net448 VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__a22oi_1
X_09045_ _02873_ _02875_ _03097_ _03098_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_92_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06188_ _00007_ _00008_ _00000_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__a21o_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09947_ _04078_ _04079_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__nor2_1
XFILLER_58_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09878_ net592 net284 _04002_ _04003_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__nand4_2
X_08829_ _02860_ _02862_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__or2_1
XFILLER_41_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10653_ _04813_ _04841_ _04840_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__o21a_1
X_10584_ _04768_ _04769_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__nor2_1
XFILLER_119_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10018_ _04155_ _04156_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nand2_1
XFILLER_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05490_ _02271_ _02260_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_27_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07160_ _01038_ _01040_ _00891_ net146 VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__a211oi_2
XFILLER_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07091_ _00956_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__nand2_1
X_06111_ _05144_ _05146_ _05239_ _05240_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__a211o_1
X_06042_ _05078_ _05171_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__xor2_1
XFILLER_117_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout206 net61 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_2
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_2
Xfanout228 net229 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_2
X_09801_ _03920_ _03921_ _03901_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__a21o_1
X_07993_ _01935_ _01948_ _01949_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__nor3_1
Xfanout239 net241 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_2
X_09732_ net395 net505 _03742_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__and3_1
X_06944_ _00804_ _00805_ _00806_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__and3_1
XFILLER_94_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06875_ _00728_ _00729_ _00730_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__a21o_1
X_09663_ _03768_ _03769_ _03770_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__a21o_1
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08614_ net401 net585 VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__nand2_1
X_09594_ net623 net282 _03694_ _03695_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__nand4_2
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05826_ _04956_ _04957_ _04958_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__or3_1
X_08545_ _02388_ _02392_ _02550_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__a21oi_1
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05757_ _04310_ _04396_ _04385_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__a21bo_1
X_08476_ _02474_ _02475_ _02473_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__o21ai_1
XFILLER_11_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05688_ _04407_ _04418_ _04429_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__nand3_2
X_07427_ _01172_ _01174_ _01173_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__a21bo_1
X_07358_ net553 net362 net354 net449 VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__a22oi_1
XFILLER_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06309_ _00069_ _00070_ _00128_ _00129_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__or4bb_2
XFILLER_108_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07289_ _01018_ _01026_ _01025_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__a21bo_1
XFILLER_40_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09028_ _03078_ _03079_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10636_ _04823_ _04824_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__nor2_1
X_10567_ _04749_ _04750_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__xnor2_1
XFILLER_115_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10498_ _04676_ _04677_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__nor2_1
XFILLER_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_110_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput6 A[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_37_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06660_ _00377_ _00384_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__or2_1
XFILLER_76_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05611_ net257 net446 VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__nand2_1
X_06591_ _00421_ _00420_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__and2b_1
X_08330_ _02297_ _02316_ _02317_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__nand3_1
X_05542_ net436 net550 net446 net343 VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__a22oi_2
X_08261_ _02239_ _02240_ _02235_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__a21o_1
X_05473_ _01617_ _02075_ _02086_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__nor3_1
X_07212_ net491 net319 _01095_ _01096_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08192_ _02156_ _02166_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_76_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07143_ _01020_ _01021_ _01019_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__o21ai_1
XFILLER_118_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07074_ net455 net364 net356 net462 VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__a22oi_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06025_ _05070_ _05154_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__xnor2_1
XFILLER_113_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07976_ _01928_ _01929_ _01930_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__and3_1
XFILLER_59_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06927_ _00635_ _00786_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__xor2_1
XFILLER_55_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09715_ _03784_ _03827_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__and3_1
XFILLER_28_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09646_ _03749_ _03750_ _03751_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__and3_1
X_06858_ _00711_ _00712_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_2_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06789_ _00635_ _00637_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__and2_1
XFILLER_55_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09577_ _03677_ _03676_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__and2b_1
XFILLER_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05809_ net213 net460 net204 net453 VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__and4_1
X_08528_ _02371_ _02375_ _02369_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__a21bo_1
X_08459_ _02441_ _02454_ _02456_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__or3_1
XFILLER_11_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10421_ _04462_ _04529_ _04532_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_98_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10352_ _04449_ _04458_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nand2_1
XFILLER_105_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10283_ _04336_ _04337_ _04335_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__o21ai_1
XFILLER_2_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout570 net17 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__buf_1
Xfanout592 net14 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__clkbuf_4
Xfanout581 net582 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__clkbuf_4
XFILLER_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10619_ _04804_ _04806_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07830_ _01763_ _01770_ _01771_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__nand3_1
XFILLER_69_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07761_ _01217_ _01696_ _01695_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__o21a_1
XFILLER_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06712_ _00551_ _00552_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__or3_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09500_ _03591_ _03593_ _03582_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07692_ _01451_ _01454_ _01452_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__a21bo_1
XFILLER_92_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06643_ _00475_ _00477_ _00354_ _00357_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09431_ _03516_ _03517_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__and2b_1
X_06574_ _00387_ _00388_ _00401_ _00402_ VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__nand4_2
X_09362_ _03441_ _03442_ _03403_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__o21a_1
X_08313_ net401 net600 VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__nand2_1
X_05525_ _02315_ _02337_ _02304_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_35_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_11 net38 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_22 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09293_ _03365_ _03367_ _03347_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__a21oi_1
X_08244_ _02220_ _02221_ VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05456_ net517 net206 net201 net604 VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__a22oi_1
X_08175_ _02139_ _02146_ _02147_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__nand3_1
X_05387_ _00440_ _00462_ _00429_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__o21bai_1
XFILLER_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07126_ net209 net200 net618 net602 VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__and4_1
X_07057_ _00777_ _00928_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__xnor2_1
XFILLER_114_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06008_ _05136_ _05137_ _05104_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_7_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07959_ _01890_ _01912_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__xor2_1
XFILLER_46_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09629_ _03732_ _03733_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__xor2_1
XFILLER_43_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10404_ _04575_ _04576_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__nor2_1
XFILLER_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10335_ _04408_ _04427_ _04409_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__a21boi_1
XFILLER_87_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10266_ _04424_ _04425_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10197_ _04348_ _04349_ _04340_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_109_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06290_ _00108_ _00109_ _00107_ VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__o21ai_1
X_05310_ net257 net493 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_32_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput31 A[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 A[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput42 B[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
Xinput53 B[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xinput64 B[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_2
XFILLER_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09980_ _04026_ _04029_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__nor2_1
X_08931_ _02891_ _02892_ _02972_ _02973_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__a22o_1
X_08862_ _02896_ _02897_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07813_ net384 net298 net362 net354 VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__and4_1
XFILLER_97_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08793_ _02780_ _02781_ _02821_ _02822_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__a2bb2o_1
X_07744_ _01507_ _01510_ _01675_ _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__a211oi_2
X_07675_ _01600_ _01601_ _01587_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_84_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06626_ _00329_ _00338_ _00337_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__a21bo_1
XFILLER_25_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09414_ _03342_ _03343_ _03346_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_51_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06557_ _00382_ _00383_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__nand2_1
X_09345_ net366 net562 _03423_ _03424_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__a22o_1
X_06488_ _00201_ _00203_ _00306_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__nand3_1
X_05508_ _02446_ _02457_ _02468_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__nand3_2
X_09276_ net159 net312 _03157_ _03155_ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__a31o_1
XFILLER_32_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08227_ _02028_ _02030_ _02204_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__a21o_1
XFILLER_20_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05439_ _01693_ _01703_ _01714_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__or3_1
XFILLER_32_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08158_ _02127_ _02128_ _01975_ _01978_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__o211ai_1
X_08089_ _02052_ _02054_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__nor2_1
X_07109_ net187 net429 net174 net166 VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__and4_1
X_10120_ net574 net285 _04267_ _04268_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__a22o_1
X_10051_ _04191_ _04192_ _04181_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__a21oi_2
XFILLER_102_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10318_ net561 net277 net268 net563 VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__a22oi_1
XFILLER_94_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10249_ _04404_ _04405_ _04406_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__nand3_1
XFILLER_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05790_ _04921_ _04922_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__nor2_1
XFILLER_93_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07460_ _01367_ _01368_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_66_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07391_ net423 net166 VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__nand2_1
X_06411_ _00123_ net150 _00229_ _00230_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_66_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06342_ _00153_ _00161_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__nand2_1
X_09130_ net154 _03190_ _03013_ _03016_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__o211ai_2
X_09061_ _02889_ _02891_ _03115_ _03116_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__a211oi_2
X_08012_ _01967_ _01968_ _01969_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__a21o_1
X_06273_ net212 net203 net387 net303 VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__and4_1
XFILLER_116_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09963_ _04094_ _04095_ _04007_ _04009_ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__o211ai_2
X_08914_ _02759_ _02767_ _02766_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_90_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09894_ _04020_ _04021_ _03920_ _03922_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__o211a_1
XFILLER_111_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08845_ _02721_ _02723_ _02877_ _02878_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__a211o_1
XFILLER_84_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08776_ _02802_ _02803_ _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__a21o_1
XFILLER_84_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07727_ _01656_ _01657_ _01648_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__a21o_1
X_05988_ _05117_ _05118_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__xnor2_1
XFILLER_38_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07658_ _01580_ _01581_ _01582_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__a21o_1
X_07589_ _01443_ _01444_ _01507_ _01509_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__or4bb_2
X_06609_ _00439_ _00441_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__and2b_1
X_09328_ _03404_ _03405_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__and2b_1
XFILLER_40_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09259_ net297 net219 net275 net267 VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__and4_1
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10103_ _04248_ _04249_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__xnor2_1
XFILLER_75_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10034_ _04066_ _04067_ _04069_ _04074_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__o31a_1
XFILLER_76_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06960_ _00820_ _00821_ _00823_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__nand3_1
X_06891_ _00683_ _00684_ _00747_ _00748_ VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__o22a_1
XFILLER_79_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05911_ _05040_ _05041_ _05033_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__a21o_1
XFILLER_39_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08630_ _02495_ _02497_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nand2_1
X_05842_ _04938_ _04939_ _04972_ _04973_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_68_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08561_ _02567_ _02568_ _02557_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__a21oi_1
XFILLER_54_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05773_ _04904_ _04905_ _04906_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__nor3b_1
X_07512_ net302 net222 net394 net378 VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__nand4_1
X_08492_ net210 net198 net533 net527 VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__nand4_1
XFILLER_90_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07443_ _01347_ _01348_ _01189_ _01193_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__a211oi_1
X_07374_ _01269_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__nand2b_1
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09113_ net399 net565 _02997_ _02996_ VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__a31o_1
XFILLER_108_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06325_ net521 net610 net365 net357 VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_79_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06256_ net552 net448 net190 net433 VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__and4_1
X_09044_ _03095_ _03096_ _03085_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_92_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap150 _00125_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_1
X_06187_ _00000_ _00007_ _00008_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__nand3_1
XFILLER_104_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09946_ net167 net243 _04077_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__and3_1
XFILLER_58_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09877_ net591 net284 _04002_ _04003_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__a22o_1
XFILLER_85_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08828_ net463 net246 VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__nand2_1
XFILLER_58_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08759_ net193 net527 VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__nand2_1
XFILLER_26_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10652_ _04813_ _04840_ _04841_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__nor3_1
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10583_ _04765_ _04766_ _04767_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10017_ _03743_ _03953_ _04154_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__o21ai_1
XFILLER_76_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07090_ _00957_ _00963_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__xnor2_1
X_06110_ _05236_ _05238_ _05081_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__a21oi_1
XFILLER_117_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06041_ _05169_ _05170_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__nand2b_1
XFILLER_113_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07992_ _01945_ _01946_ _01947_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_74_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout218 net60 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_4
Xfanout229 net233 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_2
X_09800_ _03901_ _03920_ _03921_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__nand3_2
Xfanout207 net61 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_1
X_06943_ _00650_ _00651_ _00649_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__o21bai_1
XFILLER_113_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09731_ _03845_ _03846_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__xnor2_1
XFILLER_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06874_ _00728_ _00729_ _00730_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__nand3_1
XFILLER_54_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09662_ _03768_ _03769_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__and3_1
XFILLER_67_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08613_ _02625_ _02626_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__and2b_1
XFILLER_54_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09593_ net623 net282 _03694_ _03695_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__a22o_1
X_05825_ net346 net300 net224 net439 VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__a22oi_2
X_08544_ _02388_ _02392_ _02550_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__and3_1
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05756_ _04887_ _04888_ _04880_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__a21o_1
X_08475_ _02473_ _02474_ _02475_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__or3_1
X_05687_ _03592_ _03679_ _03668_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__a21bo_1
X_07426_ _01328_ _01329_ _01327_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__o21ai_1
X_07357_ net553 net449 net362 net354 VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__and4_1
X_06308_ _00126_ _00127_ _00017_ _00019_ VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__a211o_1
X_09027_ _02856_ _02857_ _02855_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__a21oi_1
X_07288_ _01178_ _01179_ _01171_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__a21o_1
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06239_ _00051_ _00059_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__nand2_1
XFILLER_104_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09929_ _03959_ _03978_ _04058_ _04060_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__a211o_1
XFILLER_100_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10635_ _04821_ _04822_ _04819_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__a21oi_1
X_10566_ _04592_ _04662_ _04708_ _04711_ _04706_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__a32o_1
X_10497_ _04629_ _04630_ _04628_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__o21a_1
XFILLER_108_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 A[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_83_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05610_ _03548_ _03581_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__xnor2_1
XFILLER_91_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06590_ _00297_ _00300_ _00296_ VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__o21ba_1
XFILLER_17_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05541_ net436 net343 net550 net446 VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__and4_1
X_08260_ _02235_ _02239_ _02240_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__nand3_2
XFILLER_60_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05472_ _02043_ _02064_ _01573_ _01595_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__o211a_1
X_07211_ _01095_ _01096_ net491 net318 VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__and4bb_1
X_08191_ _02164_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_89_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07142_ _01019_ _01020_ _01021_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__or3_1
XFILLER_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07073_ net462 net455 net364 net356 VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__and4_1
X_06024_ _05070_ _05154_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__nand2b_1
XFILLER_87_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07975_ _01752_ _01754_ _01753_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__o21bai_1
XFILLER_101_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06926_ _00635_ _00786_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_98_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09714_ _03824_ _03826_ _03708_ _03711_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__o211ai_1
X_06857_ net195 net173 VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__nand2_1
XFILLER_28_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09645_ _03749_ _03750_ _03751_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_87_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05808_ _04877_ _04879_ _04876_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__o21ba_1
X_06788_ _00514_ _00517_ _00634_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__or3_1
X_09576_ _03565_ _03568_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__nor2_1
X_08527_ _02531_ _02532_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__nor2_1
XFILLER_70_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05739_ _04866_ _04871_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__xnor2_1
XFILLER_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08458_ _02441_ _02454_ _02456_ VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__nor3_1
XFILLER_23_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07409_ net209 net200 net596 net587 VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__nand4_1
XFILLER_50_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08389_ net457 net451 net279 net271 VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__and4_1
X_10420_ _04592_ _04593_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_98_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10351_ _04515_ _04517_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__xnor2_1
X_10282_ _04442_ _04443_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout560 net561 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__clkbuf_4
Xfanout593 net594 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__buf_2
Xfanout571 net575 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__buf_2
Xfanout582 net16 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10618_ _04774_ _04777_ _04775_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__o21ba_1
X_10549_ _04728_ _04729_ _04731_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07760_ _01367_ _01368_ _01523_ _01525_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__or4_1
XFILLER_37_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06711_ net426 net389 VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__nand2_1
XFILLER_80_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07691_ _01618_ _01619_ _01616_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__o21ai_1
XFILLER_64_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09430_ _03517_ _03516_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__and2b_1
XFILLER_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06642_ _00354_ _00357_ _00475_ _00477_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__a211o_1
XFILLER_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06573_ _00276_ _00278_ _00400_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__nand3_1
X_09361_ _03403_ _03441_ _03442_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__nor3_1
X_08312_ _02156_ _02165_ _02164_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__a21o_1
X_05524_ _02195_ _02216_ _02206_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__o21ba_1
X_09292_ _03347_ _03365_ _03367_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__and3_1
X_08243_ _02221_ _02220_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_82_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_23 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_12 net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05455_ net517 net605 net206 net201 VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__and4_1
XFILLER_118_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08174_ _02143_ _02144_ _02145_ VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__a21o_1
X_05386_ _01093_ _01104_ _01115_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__a21o_1
XFILLER_20_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07125_ net194 net625 VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__nand2_1
X_07056_ _00926_ _00927_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__and2b_1
X_06007_ _05104_ _05136_ _05137_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__nor3_2
XFILLER_114_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07958_ _01907_ _01908_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__xnor2_1
XFILLER_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06909_ _00492_ _00493_ _00628_ VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__and3b_1
X_07889_ _01833_ _01834_ _01836_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__nand3_1
XFILLER_46_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09628_ _03732_ _03733_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__nor2_1
XFILLER_102_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09559_ _03655_ _03656_ _03642_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__o21ai_1
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10403_ _04513_ _04514_ _04512_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__a21oi_1
X_10334_ _04481_ _04500_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__xor2_1
XFILLER_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10265_ net243 _04424_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__and2_1
X_10196_ _04340_ _04348_ _04349_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand3_1
XFILLER_78_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout390 net4 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__buf_4
XFILLER_78_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 A[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput21 A[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput43 B[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
Xinput32 A[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
Xinput54 B[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_4
XFILLER_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08930_ _02891_ _02892_ _02972_ _02973_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__nand4_4
XFILLER_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08861_ _02896_ _02897_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__and2_1
XFILLER_111_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07812_ net465 net340 VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__nand2_1
XFILLER_96_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08792_ _02780_ _02781_ _02821_ _02822_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__or4bb_2
X_07743_ _01607_ _01608_ _01673_ _01674_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__a2bb2oi_1
X_07674_ _01587_ _01600_ _01601_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_84_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06625_ _00456_ _00457_ _00448_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__a21o_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09413_ _03497_ _03498_ _03378_ _03380_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__a211o_1
XFILLER_52_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06556_ net610 net339 _00260_ _00259_ VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__a31o_1
X_09344_ net374 net556 net540 net391 VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__a22o_1
X_06487_ _00307_ VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__inv_2
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05507_ _01769_ _01824_ _01758_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__a21bo_1
X_09275_ _03221_ _03225_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__nand2_1
XFILLER_119_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08226_ _02048_ _02203_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__xnor2_1
X_05438_ net342 net459 net452 net435 VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__a22oi_2
XFILLER_119_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08157_ _01975_ _01978_ _02127_ _02128_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__a211o_1
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07108_ net423 net181 VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__nand2_1
X_05369_ net479 net342 net471 net435 VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__a22oi_2
XFILLER_106_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08088_ net474 net280 net272 net482 VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__a22oi_1
X_07039_ net129 _00908_ _00756_ _00759_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10050_ _04181_ _04191_ _04192_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__and3_2
XFILLER_102_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10317_ net562 net555 net277 net268 VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_115_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10248_ _04404_ _04405_ _04406_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__a21o_1
XFILLER_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10179_ _04330_ _04332_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__nand2_1
XFILLER_93_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06410_ _00191_ _00193_ _00226_ _00227_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_66_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07390_ _01287_ _01291_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_66_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06341_ _00154_ _00159_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__xnor2_1
X_06272_ net195 net468 VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__nand2_1
X_09060_ _03111_ _03114_ _02972_ _02974_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__o211a_1
X_08011_ _01967_ _01968_ _01969_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__nand3_2
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09962_ _04007_ _04009_ _04094_ _04095_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__a211o_1
X_08913_ _02952_ _02953_ _02945_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_90_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09893_ _03920_ _03922_ _04020_ _04021_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__a211oi_1
XFILLER_85_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08844_ _02721_ _02723_ _02877_ _02878_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__a211oi_2
XFILLER_111_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08775_ net422 net557 VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__and2_1
X_05987_ net216 net467 VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__nand2_1
X_07726_ _01648_ _01656_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__nand3_1
XFILLER_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07657_ _01580_ _01581_ _01582_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__and3_1
XFILLER_25_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07588_ _01505_ _01506_ _01345_ _01347_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__o211ai_1
X_06608_ _00437_ _00438_ _00433_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__a21o_1
XFILLER_13_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06539_ _00363_ _00365_ VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__nand2_1
X_09327_ net590 net328 net320 net597 VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__a22o_1
XFILLER_21_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09258_ _03327_ _03328_ _03153_ _03195_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__a211o_1
XFILLER_107_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08209_ _02155_ _02185_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__xnor2_1
X_09189_ _03120_ _03122_ _03254_ _03256_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__o211a_1
XFILLER_119_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10102_ net591 net261 VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__nand2_1
XFILLER_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10033_ _04172_ _04173_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__nand2_1
XFILLER_102_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06890_ _00683_ _00684_ _00747_ _00748_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__nor4_1
XFILLER_67_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05910_ _05033_ _05040_ _05041_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__nand3_1
X_05841_ _04938_ _04939_ _04972_ _04973_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__and4_1
XFILLER_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08560_ _02557_ _02567_ _02568_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__and3_1
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05772_ _03395_ _04548_ _04537_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__a21o_1
X_07511_ _01287_ _01290_ _01288_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__o21bai_1
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08491_ net198 net533 net527 net210 VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__a22o_1
XFILLER_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07442_ _01189_ _01193_ _01347_ _01348_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__o211a_1
XFILLER_62_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07373_ _01272_ _01273_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__xnor2_1
X_06324_ _00067_ _00069_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__nor2_1
XFILLER_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09112_ _03042_ _03045_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__nand2_1
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06255_ net454 net425 VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__nand2_1
X_09043_ _03085_ _03095_ _03096_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__and3_2
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06186_ _00004_ _00005_ _00006_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__a21o_1
XFILLER_116_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap140 net633 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap151 _00019_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
XFILLER_89_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09945_ net167 net243 _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09876_ net581 net307 net292 net584 VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__a22o_1
XFILLER_85_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08827_ _02858_ _02859_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__xnor2_1
XFILLER_58_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08758_ net210 _02783_ _02782_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__a21bo_1
XFILLER_26_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08689_ net478 net247 VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__nand2_1
X_07709_ _01637_ _01638_ _01633_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__a21o_1
XFILLER_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10651_ _04749_ _04750_ _04825_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__and3_1
X_10582_ _04766_ _04767_ _04765_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__o21a_1
XFILLER_5_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10016_ _03743_ _03953_ _04154_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__or3_1
XFILLER_91_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06040_ _05100_ _05102_ _05168_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__a21o_1
XFILLER_99_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07991_ _01945_ _01946_ _01947_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_74_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_2
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__buf_2
X_06942_ _00802_ _00803_ _00801_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09730_ _03735_ _03741_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__nor2_1
XFILLER_94_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06873_ _00585_ _00587_ _00586_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__o21bai_1
X_09661_ _03633_ _03634_ _03632_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__a21bo_1
XFILLER_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08612_ net408 net578 net571 net416 VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__a22o_1
XFILLER_54_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09592_ net597 net304 net289 net613 VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__a22o_1
X_05824_ net439 net346 net300 net224 VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__and4_1
X_08543_ _02548_ _02549_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__xnor2_1
X_05755_ _04880_ _04887_ _04888_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__nand3_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08474_ net428 net564 net557 net184 VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a22oi_2
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05686_ _04385_ _04396_ _04310_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__a21o_1
X_07425_ _01327_ _01328_ _01329_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__or3_1
XFILLER_10_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07356_ net455 net340 VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__nand2_1
XFILLER_109_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06307_ _00017_ net151 _00126_ _00127_ VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__o211ai_2
X_07287_ _01171_ _01178_ _01179_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__nand3_1
X_06238_ _00052_ _00057_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__xnor2_1
X_09026_ _03075_ _03076_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__xor2_1
X_06169_ _05294_ _05297_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09928_ _04041_ _04057_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__nor2_1
XFILLER_58_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09859_ net626 net261 _03983_ _03984_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10634_ _04766_ _04767_ _04820_ _04822_ _04819_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__o311a_1
X_10565_ _04747_ _04748_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__nor2_1
XFILLER_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10496_ _04637_ _04674_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__xor2_1
XFILLER_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 A[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_76_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05540_ net257 net452 VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__nand2_1
XFILLER_45_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05471_ _01573_ _01595_ _02043_ _02064_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__a211oi_2
XFILLER_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07210_ net477 net333 net326 net485 VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__a22oi_1
X_08190_ _02161_ _02163_ _02157_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__a21o_1
X_07141_ net348 net567 net559 net438 VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_76_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07072_ _00941_ _00944_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__xnor2_1
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06023_ _05071_ _05148_ _05149_ _05152_ _05153_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__o311a_1
XFILLER_99_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07974_ _01925_ _01926_ _01927_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__nand3_1
XFILLER_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06925_ _00632_ _00784_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__xnor2_1
XFILLER_74_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09713_ _03708_ _03711_ _03824_ _03826_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__a211o_1
X_06856_ _00709_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__nor2_1
XFILLER_67_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09644_ _03645_ _03649_ VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_87_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05807_ _04868_ _04870_ _04867_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__o21ba_1
X_06787_ _00514_ _00517_ _00634_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__o21ai_1
X_09575_ _03674_ _03675_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__nor2_1
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08526_ _02364_ _02366_ _02529_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__and3_1
X_05738_ _04866_ _04871_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__nand2b_1
X_08457_ _02451_ _02452_ _02453_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05669_ _04157_ _04212_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__xnor2_1
X_07408_ net194 net602 VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_21_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08388_ _02258_ _02295_ _02292_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__o21ai_1
X_07339_ _01107_ _01109_ _01233_ VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_98_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10350_ _04444_ _04447_ _04515_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__and3_1
X_09009_ _03056_ _03057_ _02958_ _02962_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__o211a_1
X_10281_ _04442_ _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__nand2_1
XFILLER_105_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout550 net554 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__buf_2
XFILLER_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout561 net19 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__buf_2
XFILLER_19_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout583 net589 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_2
Xfanout572 net575 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__buf_2
Xfanout594 net14 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_29_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10617_ _04802_ _04803_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__xor2_1
X_10548_ net523 net259 VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__and2_1
XFILLER_6_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10479_ net283 net508 net501 net291 VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__a22oi_1
XFILLER_96_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06710_ net432 net301 net225 net191 VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__a22oi_2
XFILLER_49_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07690_ _01616_ _01618_ _01619_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__or3_1
XFILLER_92_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06641_ _00408_ _00409_ _00472_ _00474_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_18_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06572_ _00276_ _00278_ _00400_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__a21o_1
XFILLER_17_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09360_ _03438_ _03440_ _03317_ _03321_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__o211a_1
X_08311_ _02146_ _02148_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__nand2_1
X_05523_ net141 _02108_ _02632_ _01682_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__nand4b_1
XFILLER_33_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09291_ _03362_ _03364_ _03231_ _03234_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__o211ai_1
X_08242_ _02054_ _02056_ _02052_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_82_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_13 net167 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05454_ net516 net217 _01387_ _01376_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__a31o_1
XFILLER_33_695 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_24 _03265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08173_ _02143_ _02144_ _02145_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__nand3_1
X_05385_ _01093_ _01104_ _01115_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__nand3_1
XFILLER_118_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07124_ _00868_ _00870_ _00869_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__o21ba_1
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07055_ _00924_ _00925_ _00920_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__a21o_1
X_06006_ _05133_ _05135_ _05045_ _05048_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__o211a_1
Xoutput120 net120 VGND VGND VPWR VPWR C[5] sky130_fd_sc_hd__buf_2
XFILLER_102_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07957_ _01907_ _01908_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__nand2_1
X_06908_ _00767_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__inv_2
XFILLER_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07888_ _01648_ _01657_ _01656_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__a21bo_1
X_06839_ net432 net223 net181 net191 VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__a22o_1
XFILLER_71_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09627_ _03615_ _03617_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__nor2_1
XFILLER_43_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09558_ _03642_ _03655_ _03656_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__or3_1
XFILLER_102_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08509_ _02513_ _02511_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__and2b_1
XFILLER_24_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09489_ _03468_ _03471_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__nand2_1
XFILLER_11_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10402_ _04573_ _04574_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__nand2_1
X_10333_ _04498_ _04499_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10264_ net592 net245 VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__nand2_1
XFILLER_78_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10195_ _04340_ _04348_ _04349_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__and3_1
XFILLER_93_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout380 net381 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_2
Xfanout391 net392 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__buf_2
XFILLER_93_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 A[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
Xinput11 A[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_4
Xinput44 B[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xinput55 B[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_2
Xinput33 B[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_2
XFILLER_6_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08860_ net193 net527 _02782_ _02784_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__a31o_1
X_07811_ _01749_ _01750_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_4_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08791_ _02817_ _02820_ _02661_ _02663_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__o211ai_1
X_07742_ _01607_ _01608_ _01673_ _01674_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__or4bb_1
X_07673_ _01597_ _01598_ _01599_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_84_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06624_ _00448_ _00456_ _00457_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__nand3_2
XFILLER_52_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09412_ _03378_ _03380_ _03497_ _03498_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__o211ai_2
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09343_ net391 net374 net556 net540 VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__nand4_1
X_06555_ _00380_ _00381_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__xnor2_1
XFILLER_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06486_ _00201_ _00203_ _00306_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__a21o_1
X_05506_ _02424_ _02435_ _02348_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__a21o_1
X_09274_ _03160_ _03169_ _03168_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__a21o_1
X_08225_ _02200_ _02201_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__xnor2_1
X_05437_ net435 net342 net459 net452 VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__and4_1
XFILLER_119_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08156_ _02125_ _02126_ _02112_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__o21a_1
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05368_ net435 net479 net342 net471 VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_95_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07107_ _00979_ _00982_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08087_ net482 net474 net279 net272 VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__and4_1
X_07038_ _00756_ _00759_ net129 _00908_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__a211o_1
XFILLER_88_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08989_ _03035_ _03037_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__and2b_1
XFILLER_75_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10316_ _04478_ _04479_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_115_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10247_ _04354_ _04356_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__nand2b_1
XFILLER_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10178_ net591 net249 _04329_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_37_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06340_ _00154_ _00159_ VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__nand2b_1
X_06271_ _05303_ _05305_ _05304_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__o21ba_1
X_08010_ _01792_ _01794_ _01793_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__o21bai_1
XFILLER_30_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09961_ _04007_ _04009_ _04094_ _04095_ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__a211oi_1
XFILLER_103_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08912_ _02945_ _02952_ _02953_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__nand3_1
X_09892_ _04018_ _04019_ _03878_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08843_ _02875_ _02876_ _02865_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__a21oi_2
X_08774_ net428 net542 net533 net186 VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__a22o_1
X_05986_ _05115_ _05116_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__nor2_1
X_07725_ _01653_ _01654_ _01655_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__a21o_1
X_07656_ _01412_ _01414_ _01413_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__o21bai_1
XFILLER_53_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07587_ _01345_ _01347_ _01505_ _01506_ VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__a211o_1
XFILLER_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06607_ _00433_ _00437_ _00438_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__and3_1
XFILLER_13_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06538_ _00361_ _00362_ _00236_ _00239_ VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__a211o_1
X_09326_ net597 net590 net328 net320 VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__and4_1
XFILLER_40_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09257_ _03153_ _03195_ _03327_ _03328_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__o211ai_4
XFILLER_21_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06469_ _00165_ _00168_ _00286_ _00288_ VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__a211oi_2
X_08208_ _02181_ _02182_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__xnor2_1
XFILLER_119_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09188_ _03252_ _03253_ _03129_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__a21o_1
XFILLER_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08139_ _02105_ _02106_ _02107_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__a21o_1
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10101_ _04246_ _04247_ VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__nor2_1
XFILLER_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10032_ net614 net249 _04171_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__nand3_1
XFILLER_91_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05840_ _04969_ _04971_ _04892_ _04895_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__o211ai_2
XFILLER_82_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07510_ net470 net370 _01272_ _01271_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__a31o_1
X_05771_ _04902_ _04903_ _04709_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__o21a_1
XFILLER_35_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08490_ net214 net527 _02336_ _02335_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__a31o_1
XFILLER_23_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07441_ _01307_ _01308_ _01345_ _01346_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__a2bb2o_1
X_07372_ net470 net370 VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__nand2_1
X_06323_ _00142_ _00143_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__xnor2_1
X_09111_ _03160_ _03170_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__xnor2_1
XFILLER_108_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06254_ _00071_ _00074_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__xnor2_1
X_09042_ _03093_ _03094_ _03086_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__a21o_1
X_06185_ _00004_ _00005_ _00006_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__nand3_1
XFILLER_104_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap141 _02097_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
Xmax_cap130 _04291_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
XFILLER_104_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09944_ _04075_ _04076_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__xor2_1
X_09875_ net589 net581 net307 net292 VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__nand4_2
XFILLER_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08826_ _02704_ _02705_ _02703_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05969_ _05084_ _05098_ _05099_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__nand3_2
X_08757_ net210 _02783_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__and2_1
X_08688_ _02706_ _02707_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__xnor2_1
X_07708_ _01633_ _01637_ _01638_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__and3_1
XFILLER_54_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07639_ _01560_ _01561_ _01391_ _01393_ VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__a211oi_1
XFILLER_110_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10650_ _04836_ _04838_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__xnor2_1
X_09309_ _03213_ _03216_ _03382_ _03384_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__a211o_1
XFILLER_110_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10581_ _04679_ _04723_ _04724_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__a21bo_1
XFILLER_21_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10015_ _04144_ _04153_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__xor2_1
XFILLER_48_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07990_ _01763_ _01771_ _01770_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_74_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout209 net210 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_2
X_06941_ _00801_ _00802_ _00803_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__or3_1
XFILLER_79_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09660_ _03764_ _03765_ _03767_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__nand3_1
X_08611_ net416 net408 net578 net571 VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__and4_1
X_06872_ _00726_ _00727_ _00725_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__o21ai_1
XFILLER_39_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09591_ net613 net597 net304 net289 VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__nand4_2
XFILLER_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05823_ net254 net386 VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__nand2_1
X_08542_ net478 net251 VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__and2_1
X_05754_ _04884_ _04885_ _04886_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__a21o_1
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08473_ net184 net428 net564 net557 VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__and4_1
X_07424_ net345 net544 net536 net438 VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__a22oi_2
XFILLER_23_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05685_ _04310_ _04385_ _04396_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__nand3_1
XFILLER_23_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07355_ _01250_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__xnor2_1
XFILLER_109_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06306_ _00088_ _00090_ _00123_ _00124_ VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__o22ai_2
X_07286_ _01175_ _01176_ _01177_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__a21o_1
X_06237_ _00052_ _00057_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__nand2b_1
X_09025_ net445 net251 _03075_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nand3_1
XFILLER_40_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06168_ _05295_ _05296_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__nor2_1
X_06099_ _05194_ _05227_ _05228_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__nor3_1
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09927_ _04041_ _04057_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__and2_1
XFILLER_105_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09858_ net598 net278 net270 net613 VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__a22oi_1
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08809_ _02682_ _02684_ _02838_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__and3_1
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09789_ _03904_ _03907_ _03909_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_44_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10633_ _04764_ _04798_ _04796_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__o21a_1
XFILLER_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10564_ _04745_ _04746_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__nor2_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10495_ _04674_ _04637_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__and2b_1
XFILLER_114_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 A[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_76_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05470_ _02021_ _02032_ _01529_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07140_ net437 net344 net567 net559 VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__and4_1
XFILLER_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07071_ _00942_ _00943_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_76_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06022_ _05066_ _05150_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__nand2_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07973_ _01925_ _01926_ _01927_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__a21o_1
X_09712_ _03822_ _03823_ _03661_ _03663_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__o211a_1
X_06924_ _00632_ _00784_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__nand2_1
XFILLER_82_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06855_ net205 net165 net626 net211 VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__a22oi_1
XFILLER_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09643_ _03747_ _03748_ _03626_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_87_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09574_ _03672_ _03673_ net176 net258 VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__and4bb_1
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05806_ _04936_ _04937_ _04920_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__a21o_1
X_06786_ _00632_ _00633_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__nor2_1
X_08525_ _02530_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__inv_2
XFILLER_82_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05737_ _04869_ _04870_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__xnor2_1
X_08456_ _02454_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__inv_2
XFILLER_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05668_ _04157_ _04212_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__and2b_1
X_08387_ _02232_ _02253_ _02252_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__a21boi_1
X_07407_ _01166_ _01168_ _01167_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__o21bai_1
XFILLER_51_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07338_ _01107_ _01109_ _01233_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__o21ai_1
XFILLER_109_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05599_ _03450_ _03461_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__nor2_1
XFILLER_109_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07269_ _01156_ _01160_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__xnor2_1
X_09008_ _02958_ _02962_ _03056_ _03057_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__a211oi_2
XFILLER_2_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10280_ _04370_ _04372_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__or2_1
XFILLER_116_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout551 net554 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__buf_1
Xfanout540 net543 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__buf_2
XFILLER_86_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout584 net589 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__clkbuf_4
Xfanout562 net18 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__clkbuf_4
Xfanout573 net574 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__buf_2
Xfanout595 net14 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_29_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10616_ net507 net248 VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__nand2_1
X_10547_ net266 net507 net500 net275 VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__a22o_1
X_10478_ net283 net523 _04588_ _04587_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__a31o_1
XFILLER_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06640_ _00408_ _00409_ _00472_ _00474_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__or4bb_1
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06571_ _00389_ _00398_ VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__xnor2_1
X_08310_ _02258_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__xor2_1
X_05522_ _02599_ _02621_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__and2b_1
X_09290_ _03365_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__inv_2
X_08241_ _02218_ _02219_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_82_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_14 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05453_ _01835_ _01846_ _01857_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_25 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08172_ _01964_ _01965_ _01963_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__a21bo_1
X_05384_ _01093_ _01104_ _01115_ VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__and3_1
XFILLER_118_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07123_ _00858_ _00860_ _00859_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__o21ba_1
XFILLER_118_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07054_ _00920_ _00924_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__and3_1
Xoutput110 net110 VGND VGND VPWR VPWR C[50] sky130_fd_sc_hd__buf_2
X_06005_ _05045_ _05048_ _05133_ _05135_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__a211oi_4
Xoutput121 net121 VGND VGND VPWR VPWR C[60] sky130_fd_sc_hd__buf_2
XFILLER_102_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07956_ _01907_ _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__or2_1
XFILLER_102_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06907_ _00489_ _00491_ _00627_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07887_ _01831_ _01832_ _01823_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__a21o_1
XFILLER_28_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06838_ net191 net432 net223 net181 VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__nand4_1
X_09626_ _03730_ _03731_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__xnor2_1
X_06769_ _00613_ _00614_ _00501_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_54_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09557_ _03652_ _03653_ _03654_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08508_ _02320_ _02346_ _02345_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__a21oi_1
X_09488_ _03409_ _03418_ _03416_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__a21o_1
XFILLER_24_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08439_ _02265_ _02267_ _02266_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__o21bai_1
XFILLER_51_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10401_ _04571_ _04572_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__nand2_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10332_ net589 net244 VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__nand2_1
X_10263_ _04422_ _04423_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__xnor2_1
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10194_ _04345_ _04346_ _04341_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__a21o_1
XFILLER_78_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout370 net373 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkbuf_4
Xfanout381 net382 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_21_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout392 net395 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput12 A[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_30_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput23 A[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput45 B[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput34 B[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
Xinput56 B[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07810_ net451 net317 VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__nand2_1
XFILLER_111_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08790_ _02661_ _02663_ _02817_ _02820_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_4_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07741_ _01607_ _01608_ _01673_ _01674_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__and4bb_1
XFILLER_84_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07672_ _01597_ _01598_ _01599_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_84_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06623_ _00453_ _00454_ _00455_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__a21o_1
XFILLER_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09411_ _03493_ _03496_ _03371_ _03373_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__o211ai_2
X_06554_ net521 net339 VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__nand2_1
XFILLER_52_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09342_ net399 net540 _03279_ _03278_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__a31o_1
XFILLER_80_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05505_ _02348_ _02424_ _02435_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__nand3_1
X_06485_ _00295_ _00304_ VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__xnor2_1
XFILLER_60_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09273_ _03344_ _03345_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__xor2_1
X_08224_ _02201_ _02200_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__nand2b_1
X_05436_ net257 net471 VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08155_ _02112_ _02125_ _02126_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__nor3_1
X_05367_ _00919_ _00930_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__nor2_1
XFILLER_119_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07106_ _00980_ _00981_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__nor2_1
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08086_ _01918_ _01954_ _01952_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__o21ai_1
X_07037_ _00905_ _00906_ _00641_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__o21a_1
XFILLER_114_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08988_ _03032_ _03033_ _03034_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__a21o_1
X_07939_ _01751_ _01760_ _01759_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__a21o_1
XFILLER_87_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09609_ _03556_ _03558_ _03710_ _03713_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_104_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10315_ _04478_ _04479_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_115_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10246_ _04347_ _04350_ _04403_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__o21ai_1
XFILLER_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10177_ net591 net249 _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__a21o_1
XFILLER_94_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06270_ _05294_ _05296_ _05295_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__o21ba_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09960_ _04091_ _04093_ _04082_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__a21oi_2
X_08911_ _02950_ _02951_ _02946_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__a21o_1
X_09891_ _03878_ _04018_ _04019_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__and3_1
XFILLER_111_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08842_ _02865_ _02875_ _02876_ VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__and3_2
X_08773_ net186 net428 net542 net533 VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__nand4_1
X_05985_ net231 net386 net300 net241 VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__a22oi_1
XFILLER_72_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07724_ _01653_ _01654_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__nand3_1
X_07655_ _01578_ _01579_ _01577_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__o21ai_1
XFILLER_53_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06606_ _00434_ _00435_ _00436_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__a21bo_1
X_07586_ _01503_ _01504_ _01467_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__o21a_1
XFILLER_53_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06537_ _00236_ _00239_ _00361_ _00362_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__o211ai_2
X_09325_ _03401_ _03402_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__or2_1
XFILLER_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06468_ _00283_ _00285_ _00189_ _00192_ VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__o211a_1
X_09256_ _03325_ _03326_ _03287_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__o21ai_2
X_08207_ _02182_ _02181_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__and2b_1
X_05419_ net604 net206 net201 net627 VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__a22oi_1
XFILLER_21_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06399_ _00216_ _00217_ _00209_ VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__a21o_1
X_09187_ _03129_ _03252_ _03253_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__nand3_1
XFILLER_5_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08138_ _02105_ _02106_ _02107_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__and3_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08069_ _02033_ _02031_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__nand2b_1
X_10100_ net577 net276 net268 net583 VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__a22oi_1
XFILLER_108_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10031_ net614 net249 _04171_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__a21o_1
XFILLER_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10229_ net314 net523 VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand2_1
XFILLER_67_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_68_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05770_ _04709_ _04902_ _04903_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__nor3_1
XFILLER_81_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07440_ _01307_ _01308_ _01345_ _01346_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__or4bb_2
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07371_ _01270_ _01271_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__nor2_1
XFILLER_50_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06322_ _00036_ _00044_ VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__nor2_1
X_09110_ _03168_ _03169_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__and2b_1
X_09041_ _03086_ _03093_ _03094_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__nand3_2
X_06253_ _00072_ _00073_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_79_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06184_ _05211_ _05213_ _05212_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__o21bai_1
XFILLER_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap131 _01680_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
Xmax_cap153 _00971_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap142 _03061_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_1
X_09943_ _03990_ _03991_ _03989_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09874_ net581 net314 _03860_ _03859_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__a31o_1
X_08825_ _02856_ _02857_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__xnor2_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05968_ _05096_ _05097_ _05089_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__a21o_1
X_08756_ net198 net511 net503 VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__and3_1
X_08687_ _02548_ _02549_ _02547_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__a21oi_1
X_07707_ _01635_ _01636_ _01634_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__a21bo_1
X_05899_ _05029_ _05030_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__nor2_1
XFILLER_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07638_ _01391_ _01393_ _01560_ _01561_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__o211a_1
XFILLER_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07569_ net345 net536 net529 net437 VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09308_ _03213_ _03216_ _03382_ _03384_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__a211oi_1
X_10580_ _04681_ _04686_ _04725_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__and3_1
XFILLER_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09239_ net366 net572 _03306_ _03307_ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__nand4_1
XFILLER_119_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10014_ _04151_ _04152_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06940_ net462 net364 net356 net477 VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__a22oi_2
XFILLER_79_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06871_ _00725_ _00726_ _00727_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__or3_1
XFILLER_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08610_ _02492_ _02499_ _02498_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__a21bo_1
XFILLER_55_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05822_ _04953_ _04954_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__xnor2_1
XFILLER_94_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09590_ net597 net312 _03522_ _03521_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__a31o_1
XFILLER_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08541_ _02545_ _02546_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__xnor2_1
XFILLER_63_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05753_ _04884_ _04885_ _04886_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__nand3_1
X_08472_ net422 net571 VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__nand2_1
X_05684_ _04353_ _04364_ _04375_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__a21o_1
XFILLER_90_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07423_ net437 net344 net544 net536 VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__and4_1
XFILLER_23_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07354_ _01251_ _01252_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__nor2_1
X_06305_ _00088_ _00090_ _00123_ _00124_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__or4_1
X_07285_ _01175_ _01176_ _01177_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__nand3_1
XFILLER_108_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06236_ _00055_ _00056_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__xnor2_1
X_09024_ net445 net251 VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__nand2_1
XFILLER_117_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06167_ net203 net468 net387 net211 VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__a22oi_1
XFILLER_2_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_68_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06098_ _05224_ _05226_ _05131_ _05134_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__o211a_1
XFILLER_49_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09926_ _04046_ _04056_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09857_ net613 net598 net278 net270 VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__and4_1
X_08808_ _02839_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__inv_2
X_09788_ net599 net283 _03905_ _03906_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__nand4_2
XFILLER_45_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08739_ net367 net601 _02761_ _02762_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_77_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10632_ _04766_ _04767_ _04820_ VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_24_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10563_ _04745_ _04746_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__and2_1
XFILLER_5_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10494_ _04670_ _04671_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__xnor2_1
XFILLER_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07070_ net485 net333 net326 net491 VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06021_ _05071_ _05151_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__nand2_1
XFILLER_99_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07972_ net384 net340 VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__and2_1
X_09711_ _03661_ _03663_ _03822_ _03823_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__a211o_1
X_06923_ _00774_ _00782_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__xnor2_1
XFILLER_67_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06854_ net211 net205 net165 net626 VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__and4_1
X_09642_ _03626_ _03747_ _03748_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__or3_1
X_06785_ net632 net310 _00631_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_87_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09573_ net176 net258 _03672_ _03673_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05805_ _04920_ _04936_ _04937_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__nand3_1
X_08524_ _02364_ _02366_ _02529_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__a21o_1
XFILLER_82_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05736_ net480 net196 VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nand2_1
X_08455_ _02451_ _02452_ _02453_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__and3_1
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05667_ _04190_ _04201_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__xnor2_1
X_08386_ _02377_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__inv_2
X_07406_ net194 net618 _01160_ _01157_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__a31o_1
XFILLER_50_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05598_ net480 net207 net201 net486 VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__a22oi_1
X_07337_ _01107_ _01109_ _01233_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_21_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_98_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07268_ _01157_ _01158_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__nor2_1
X_07199_ _00780_ _00932_ _00931_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__a21oi_1
X_09007_ _03054_ _03055_ _02919_ _02921_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__o211a_1
X_06219_ _05154_ _05245_ VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__and2_1
XFILLER_3_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout541 net542 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__buf_2
Xfanout530 net22 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__buf_2
XFILLER_116_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout552 net554 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__buf_2
Xfanout574 net575 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__clkbuf_4
Xfanout563 net18 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlymetal6s2s_1
X_09909_ _04037_ _04039_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__xnor2_1
Xfanout596 net14 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__buf_1
Xfanout585 net586 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__buf_2
XFILLER_58_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10615_ net259 net500 _04688_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_94_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10546_ net275 net266 net507 net500 VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__nand4_1
XFILLER_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10477_ _04653_ _04654_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__xnor2_1
XFILLER_44_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06570_ _00389_ _00398_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__nand2_1
XFILLER_64_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05521_ _02577_ _02588_ _02075_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__a21o_1
XFILLER_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08240_ net482 net263 VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05452_ _01835_ _01846_ _01857_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__and3_1
XANTENNA_15 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _02141_ _02142_ _02140_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_26 net329 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07122_ _00997_ _00998_ _00846_ _00848_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__a211oi_1
X_05383_ _00418_ _00473_ _00407_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__a21bo_1
X_07053_ _00921_ _00922_ _00923_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__a21bo_1
Xoutput100 net100 VGND VGND VPWR VPWR C[41] sky130_fd_sc_hd__buf_2
X_06004_ _05131_ _05132_ _05114_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__a21oi_2
Xoutput122 net122 VGND VGND VPWR VPWR C[61] sky130_fd_sc_hd__buf_2
Xoutput111 net111 VGND VGND VPWR VPWR C[51] sky130_fd_sc_hd__buf_2
XFILLER_99_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07955_ _01731_ _01733_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__nor2_1
XFILLER_102_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06906_ _00249_ _00492_ _00628_ _00369_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__and4bb_1
X_07886_ _01823_ _01831_ _01832_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__nand3_1
XFILLER_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09625_ _03575_ _03576_ _03579_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__o21ai_1
X_06837_ _00688_ _00689_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__xnor2_1
XFILLER_83_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06768_ _00501_ _00613_ _00614_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__nor3_2
XFILLER_70_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09556_ _03652_ _03653_ _03654_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__and3_1
XFILLER_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06699_ _00426_ _00430_ _00536_ _00539_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__a211oi_1
X_08507_ _02509_ _02510_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__and2b_1
X_09487_ _03577_ _03578_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__xor2_1
X_05719_ _04752_ _04763_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__nor2_1
X_08438_ _02432_ _02433_ _02431_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__o21ai_1
XFILLER_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08369_ _02356_ _02357_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__xnor2_1
X_10400_ _04571_ _04572_ VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__or2_1
XFILLER_109_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10331_ _04496_ _04497_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__nor2_1
X_10262_ _04328_ _04332_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__nand2_1
XFILLER_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10193_ _04341_ _04345_ _04346_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__nand3_1
XFILLER_87_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout371 net373 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
Xfanout393 net394 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_2
XFILLER_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout382 net40 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkbuf_4
Xfanout360 net361 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_109_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 A[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
Xinput46 B[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput24 A[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput35 B[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
XFILLER_115_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 B[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
X_10529_ _04708_ _04710_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__xor2_1
XFILLER_115_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07740_ _01670_ _01672_ _01503_ _01505_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__a211o_1
X_07671_ _01423_ _01430_ _01429_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_84_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06622_ _00453_ _00454_ _00455_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__nand3_1
X_09410_ _03371_ _03373_ _03493_ _03496_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__a211o_1
X_06553_ _00378_ _00379_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__and2b_1
XFILLER_52_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09341_ _03306_ _03310_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__nand2_1
X_05504_ _02391_ _02402_ _02413_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__a21o_1
XFILLER_33_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06484_ _00295_ _00304_ VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__and2_1
XFILLER_32_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09272_ _03344_ _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__or2_1
XFILLER_119_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08223_ _01870_ _02025_ _02024_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__o21a_1
X_05435_ _00778_ _01660_ _01628_ _01617_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__and4bb_2
XFILLER_21_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08154_ _02122_ _02123_ _02124_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__a21oi_1
X_05366_ _00778_ _00898_ _00669_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08085_ _01890_ _01910_ _01909_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__a21boi_2
X_07105_ net302 net409 net222 net417 VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__a22oi_1
XFILLER_106_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07036_ _00641_ _00905_ _00906_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_95_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987_ _03032_ _03033_ _03034_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__and3_1
X_07938_ _01887_ _01888_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__xnor2_1
XFILLER_102_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07869_ _01809_ _01812_ _01814_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__and3_1
XFILLER_56_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09608_ _03708_ _03709_ _03689_ VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09539_ _03632_ _03633_ _03634_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_104_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10314_ _04402_ _04405_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_115_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10245_ _04347_ _04350_ _04403_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__or3_1
X_10176_ _04326_ _04327_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout190 net191 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
XFILLER_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08910_ _02946_ _02950_ _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__nand3_1
X_09890_ _04015_ _04017_ _03998_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__a21o_1
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08841_ _02873_ _02874_ _02866_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_90_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08772_ _02799_ _02800_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__xnor2_1
X_05984_ net241 net231 net386 net300 VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__and4_1
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07723_ _01485_ _01488_ _01487_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__a21bo_1
X_07654_ _01577_ _01578_ _01579_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__or3_1
XFILLER_93_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06605_ _00436_ _00435_ _00434_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__nand3b_1
X_07585_ _01467_ _01503_ _01504_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__nor3_2
XFILLER_13_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06536_ _00359_ _00360_ _00258_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__a21o_1
X_09324_ _03275_ _03283_ _03400_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__and3_1
X_06467_ _00189_ _00192_ _00283_ _00285_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__a211oi_2
X_09255_ _03287_ _03325_ _03326_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__or3_2
X_08206_ _01991_ _02007_ _02006_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__o21a_1
X_05418_ net604 net627 net206 net201 VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__and4_1
X_06398_ _00209_ _00216_ _00217_ VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__nand3_1
X_09186_ _03250_ _03251_ _03115_ _03117_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__a211o_1
XFILLER_111_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08137_ _01926_ _01927_ _01925_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__a21bo_1
X_05349_ _00735_ _00691_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__and2b_1
X_08068_ _01542_ _01860_ _01859_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__a21boi_2
XFILLER_108_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07019_ _00867_ _00885_ _00886_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__nand3_1
XFILLER_0_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10030_ _04169_ _04170_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__xnor2_1
XFILLER_88_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10228_ _04383_ _04384_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__and2b_1
X_10159_ _04139_ _04311_ _04309_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__o21ai_1
XFILLER_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07370_ net388 net302 net394 net378 VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__and4_1
XFILLER_62_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06321_ _00034_ _00141_ VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__xor2_1
XFILLER_15_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06252_ net461 net419 net411 net476 VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__a22oi_1
X_09040_ _03090_ _03092_ _03087_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__a21o_1
XFILLER_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06183_ _00002_ _00003_ _00001_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__o21ai_1
Xmax_cap132 _00902_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
XFILLER_104_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09942_ _04071_ _04073_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__xnor2_1
Xmax_cap154 _03187_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_1
XFILLER_100_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09873_ _03905_ _03909_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nand2_1
XFILLER_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08824_ net456 net251 VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__and2_1
XFILLER_38_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08755_ net198 net511 net503 net210 VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__a22o_1
XFILLER_72_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07706_ _01634_ _01635_ _01636_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__nand3b_1
X_05967_ _05089_ _05096_ _05097_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__nand3_1
X_08686_ _02704_ _02705_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__xnor2_1
XFILLER_65_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05898_ net231 net467 net386 net241 VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__a22oi_1
X_07637_ _01557_ _01558_ _01386_ _01389_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__o211ai_2
XFILLER_13_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07568_ net437 net345 net536 net529 VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__nand4_1
XFILLER_13_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06519_ _00339_ _00340_ _00341_ VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__a21o_1
X_09307_ _03380_ _03381_ _03248_ _03250_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__o211a_1
XFILLER_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07499_ _01408_ _01410_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__xnor2_1
X_09238_ net366 net572 _03306_ _03307_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__a22o_1
XFILLER_119_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09169_ _03230_ _03232_ _03093_ _03095_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__o211ai_2
XFILLER_5_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_112_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10013_ _04148_ _04149_ _04150_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__a21o_1
XFILLER_49_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06870_ net347 net581 net574 net440 VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__a22oi_2
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05821_ net216 net446 VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__nand2_1
XFILLER_94_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08540_ _02546_ _02545_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__and2b_1
XFILLER_63_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05752_ _04320_ _04342_ _04331_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__o21bai_1
X_08471_ _02467_ _02471_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__xnor2_1
XFILLER_63_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05683_ _04353_ _04364_ _04375_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__nand3_1
X_07422_ net256 net559 VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__nand2_1
XFILLER_23_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_114_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07353_ net462 net331 net326 net475 VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__a22oi_1
XFILLER_50_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06304_ _00088_ _00090_ _00123_ _00124_ VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__nor4_1
X_07284_ _01019_ _01021_ _01020_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__o21bai_1
X_06235_ net521 net371 VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__nand2_1
X_09023_ _03072_ _03073_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__xnor2_1
XFILLER_117_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06166_ net211 net203 net468 net387 VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__and4_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06097_ _05131_ _05134_ _05224_ _05226_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__a211oi_2
X_09925_ _04054_ _04055_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__and2b_1
XFILLER_105_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09856_ _03980_ _03981_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__or2_1
X_08807_ _02682_ _02684_ _02838_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__a21o_1
XFILLER_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06999_ _00856_ _00864_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__xnor2_1
X_09787_ net599 net283 _03905_ _03906_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__a22o_1
XFILLER_100_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08738_ net367 net601 _02761_ _02762_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__a22o_1
X_08669_ _02685_ _02686_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__xor2_1
XFILLER_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10631_ _04760_ _04761_ _04796_ _04798_ VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__a31o_1
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10562_ _04523_ _04661_ _04707_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10493_ _04625_ _04626_ _04670_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__and3_1
XFILLER_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06020_ _05066_ _05150_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__nor2_1
XFILLER_114_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07971_ net220 net362 net354 net299 VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__a22o_1
X_06922_ _00774_ _00780_ _00781_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__or3_1
X_09710_ _03661_ _03663_ _03822_ _03823_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__a211oi_1
XFILLER_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06853_ _00579_ _00581_ _00580_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__o21ba_1
X_09641_ _03745_ _03746_ net368 net535 VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__and4bb_1
X_06784_ net632 net310 _00631_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_87_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09572_ net159 net274 net265 net168 VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__a22oi_1
XFILLER_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05804_ _04872_ _04874_ _04935_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__nand3_1
X_08523_ _02376_ _02528_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__xnor2_1
XFILLER_70_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05735_ _04867_ _04868_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__nor2_1
X_08454_ _02276_ _02284_ _02283_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__a21bo_1
XFILLER_50_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05666_ net486 net196 VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__nand2_1
X_08385_ _02213_ _02256_ _02255_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__o21ai_1
X_07405_ _01305_ _01306_ _01145_ _01147_ VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__a211oi_1
X_05597_ net479 net486 net207 net201 VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__and4_1
X_07336_ _01222_ _01231_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__xnor2_1
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07267_ net200 net602 net596 net209 VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__a22oi_1
X_09006_ _02919_ _02921_ _03054_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__a211oi_4
XFILLER_117_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07198_ _01065_ _01080_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__xnor2_1
X_06218_ _05071_ _00039_ _05246_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__o21ai_1
X_06149_ net453 net447 net190 net433 VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__and4_1
XFILLER_2_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout520 net521 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__buf_2
XFILLER_78_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout542 net543 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__clkbuf_2
Xfanout531 net538 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__clkbuf_4
Xfanout553 net554 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout564 net565 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__buf_2
X_09908_ _03947_ _03950_ _03946_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__a21oi_1
Xfanout575 net17 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09839_ _03961_ _03963_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__and2b_1
Xfanout586 net589 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__buf_2
Xfanout597 net598 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__buf_2
XFILLER_58_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10614_ _04778_ _04779_ _04782_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__o21ba_1
X_10545_ net275 net266 net507 net500 VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__and4_1
XFILLER_6_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10476_ net563 net244 VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__nand2_1
XFILLER_108_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05520_ _02599_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_82_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05451_ _01366_ _01420_ _01355_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__a21bo_1
XANTENNA_27 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08170_ _02140_ _02141_ _02142_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__or3_1
XFILLER_60_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_16 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07121_ _00846_ _00848_ _00997_ _00998_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__o211a_1
X_05382_ _01017_ _01028_ _01082_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__a21o_1
XFILLER_20_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07052_ _00923_ _00922_ _00921_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__nand3b_1
Xoutput101 net101 VGND VGND VPWR VPWR C[42] sky130_fd_sc_hd__buf_2
X_06003_ _05114_ _05131_ _05132_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__nand3_1
Xoutput123 net123 VGND VGND VPWR VPWR C[62] sky130_fd_sc_hd__buf_2
Xoutput112 net112 VGND VGND VPWR VPWR C[52] sky130_fd_sc_hd__buf_2
X_07954_ _01905_ _01906_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__or2_1
XFILLER_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06905_ _00624_ _00763_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__xor2_1
XFILLER_68_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07885_ _01828_ _01829_ _01830_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__a21o_1
XFILLER_110_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06836_ net552 net403 VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__nand2_1
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09624_ _03728_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__xnor2_1
X_06767_ _00610_ _00612_ _00472_ _00476_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__o211a_1
XFILLER_83_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09555_ _03538_ _03545_ _03544_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__a21bo_1
XFILLER_36_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06698_ _00533_ _00535_ _00519_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__o21a_1
X_08506_ _02486_ _02487_ _02507_ _02508_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__a22o_1
X_09486_ _03577_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__or2_1
X_05718_ net487 net189 net431 net494 VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__a22oi_1
X_08437_ _02431_ _02432_ _02433_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__or3_1
XFILLER_24_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05649_ net494 net189 net431 net517 VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__a22oi_1
XFILLER_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08368_ _02356_ _02357_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nand2_1
XFILLER_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07319_ _01213_ _01215_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__xnor2_1
X_08299_ _02280_ _02281_ _02277_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__a21o_1
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10330_ _04416_ _04421_ _04495_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__a21oi_1
X_10261_ _04420_ _04421_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__nand2_1
XFILLER_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10192_ _04341_ _04345_ _04346_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_6_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout350 net352 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_2
Xfanout372 net373 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout383 net390 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__buf_2
Xfanout361 net42 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__buf_2
XFILLER_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout394 net395 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_4
XFILLER_27_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput25 A[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput14 A[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_2
Xinput36 B[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput47 B[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_4
XFILLER_116_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10528_ _04592_ _04662_ _04661_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__a21bo_1
Xinput58 B[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10459_ _04634_ _04636_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__xor2_1
XFILLER_111_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07670_ _01594_ _01596_ _01588_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_84_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06621_ _00330_ _00333_ _00332_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__o21bai_1
XFILLER_18_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06552_ net491 net364 net356 net498 VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__a22o_1
X_09340_ _03409_ _03419_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__xnor2_1
X_05503_ _02391_ _02402_ _02413_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__nand3_1
XFILLER_33_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09271_ net549 net245 VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__nand2_1
X_08222_ _02049_ _02199_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__xnor2_1
X_06483_ _00301_ _00302_ VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05434_ _00898_ _01639_ _01660_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__nor3_1
XFILLER_20_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08153_ _02122_ _02123_ _02124_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__and3_1
X_05365_ _00669_ _00778_ _00898_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__and3_1
XFILLER_119_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08084_ _01914_ _01916_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__nand2_1
X_07104_ net417 net302 net409 net222 VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__and4_1
X_07035_ _00903_ _00904_ _00751_ _00753_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_95_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08986_ _02935_ _02936_ _02934_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__a21bo_1
X_07937_ net608 net247 VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07868_ net193 net578 _01810_ _01811_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__nand4_1
XFILLER_56_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07799_ _01735_ _01737_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__or2_1
X_06819_ _00661_ _00668_ _00670_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__nand3_1
XFILLER_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09607_ _03710_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__inv_2
X_09538_ _03632_ _03633_ _03634_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__a21o_1
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09469_ _03520_ _03558_ _03560_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__and3_1
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10313_ _04476_ _04477_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__nand2_1
XFILLER_3_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10244_ _04390_ _04401_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10175_ _04327_ _04326_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__nand2b_1
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout180 net183 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_2
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08840_ _02866_ _02873_ _02874_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_90_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08771_ net400 net579 VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__nand2_1
X_05983_ _05105_ _05113_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__xor2_1
XFILLER_84_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07722_ _01651_ _01652_ _01649_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__o21ai_1
XFILLER_27_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07653_ net384 net362 net354 net465 VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__a22oi_2
XFILLER_65_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06604_ net195 net223 VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__nand2_1
XFILLER_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07584_ _01500_ _01502_ _01339_ _01342_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__o211a_1
X_09323_ _03275_ _03283_ _03400_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__a21oi_2
X_06535_ _00258_ _00359_ _00360_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__nand3_2
XFILLER_33_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06466_ _00280_ _00282_ _00268_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__o21a_1
X_09254_ net152 _03324_ _03185_ _03188_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__o211a_1
X_08205_ _02167_ _02180_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__xor2_1
X_09185_ _03115_ _03117_ _03250_ _03251_ VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__o211ai_2
X_05417_ net605 net217 _01061_ _01039_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__a31o_1
X_08136_ _02103_ _02104_ _02102_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__o21ai_1
X_06397_ _00213_ _00214_ _00215_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__a21o_1
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05348_ _00702_ _00724_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__nor2_1
X_08067_ _01868_ _02029_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__xor2_2
XFILLER_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07018_ _00867_ _00885_ _00886_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__and3_1
XFILLER_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08969_ _02995_ _03013_ _03015_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__nand3_2
XFILLER_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10227_ net322 net508 net502 net335 VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__a22o_1
X_10158_ _04128_ _04225_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__nand2_1
XFILLER_66_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10089_ _04232_ _04234_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__nor2_1
XFILLER_35_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06320_ _00139_ _00140_ VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__nor2_1
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06251_ net476 net461 net419 net411 VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__and4_1
X_06182_ _00001_ _00002_ _00003_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_92_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap133 _03719_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
XFILLER_89_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap155 _02961_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_1
X_09941_ _04071_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__nand2_1
XFILLER_97_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09872_ _03863_ _03871_ _03870_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__a21o_1
XFILLER_85_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08823_ _02853_ _02854_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__xnor2_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08754_ _02778_ _02779_ _02613_ _02616_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__o211a_1
XFILLER_57_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05966_ _05093_ _05094_ _05095_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__a21o_1
X_07705_ net199 net580 net571 net208 VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__a22o_1
XFILLER_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08685_ net457 net252 VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__and2_1
X_05897_ net241 net231 net467 net386 VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__and4_1
XFILLER_38_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07636_ _01559_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__inv_2
XFILLER_81_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07567_ net256 net544 VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__and2_1
XFILLER_13_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06518_ _00339_ _00340_ _00341_ VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__nand3_4
X_09306_ _03382_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__inv_2
X_07498_ net475 net316 VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__nand2_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09237_ net374 net565 net556 net391 VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__a22o_1
X_06449_ _00266_ _00267_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__xor2_1
X_09168_ _03093_ _03095_ _03230_ _03232_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__a211o_2
XFILLER_5_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08119_ _01903_ _01905_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__nor2_1
X_09099_ _03155_ _03157_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__and2b_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10012_ _04148_ _04149_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__and3_1
XFILLER_91_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05820_ _04951_ _04952_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__nor2_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05751_ _04882_ _04883_ _04881_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__o21ai_1
X_08470_ _02469_ _02470_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__and2b_1
X_05682_ _03603_ _03624_ _03614_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__o21bai_1
XFILLER_35_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07421_ _01321_ _01325_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__xnor2_1
X_07352_ net475 net462 net331 net326 VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__and4_1
X_06303_ _00120_ _00122_ _00012_ _00015_ VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__o211a_1
X_07283_ _01173_ _01174_ _01172_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__a21o_1
XFILLER_108_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06234_ _00053_ _00054_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__nor2_1
X_09022_ _03070_ _03071_ _03073_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__or3_1
X_06165_ net195 net551 VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__nand2_1
XFILLER_117_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06096_ _05222_ _05223_ _05205_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__a21oi_1
X_09924_ _04051_ _04052_ _04053_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__a21o_1
XFILLER_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09855_ _03857_ _03876_ _03979_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__and3_1
XFILLER_105_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08806_ _02694_ _02837_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06998_ _00856_ _00864_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__nand2b_1
XFILLER_58_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09786_ net583 net306 net291 net590 VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__a22o_1
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08737_ net375 net594 net586 net392 VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__a22o_1
X_05949_ _05078_ _05079_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__nand2_1
X_08668_ _02685_ _02686_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__or2_1
XFILLER_26_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07619_ _01375_ _01541_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__nor2_1
XFILLER_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08599_ _02608_ _02609_ _02611_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_62_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10630_ _04818_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__inv_2
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10561_ _04743_ _04744_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__xnor2_1
X_10492_ _04622_ _04670_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__and2_1
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07970_ net299 net220 net362 net354 VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__nand4_1
XFILLER_113_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06921_ _00780_ _00781_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__nor2_1
XFILLER_101_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06852_ _00569_ _00573_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__and2b_1
X_09640_ net367 net535 _03745_ _03746_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__o2bb2a_1
X_06783_ net632 net318 _00503_ _00502_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__a31o_1
XFILLER_82_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09571_ net168 net159 net274 net265 VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__and4_1
X_05803_ _04872_ _04874_ _04935_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__a21o_1
X_08522_ _02525_ _02526_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05734_ net207 net460 net202 net472 VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__a22oi_1
X_08453_ _02449_ _02450_ _02442_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__a21o_1
XFILLER_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07404_ _01145_ _01147_ _01305_ _01306_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__o211a_1
XFILLER_50_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05665_ _04168_ _04179_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__nor2_1
X_08384_ net496 net246 _02230_ _02229_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a31o_1
XFILLER_51_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05596_ _02785_ _02807_ _02774_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__o21ba_1
X_07335_ _01222_ _01231_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_21_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07266_ net209 net200 net602 net596 VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_98_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09005_ _03052_ _03053_ _03039_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__o21a_1
X_06217_ _05066_ _05245_ _05150_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__o21ai_1
X_07197_ _01065_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__and2_1
XFILLER_117_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06148_ net463 net425 VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__nand2_1
XFILLER_104_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06079_ _05207_ _05208_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__nor2_1
Xfanout521 net522 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__buf_2
XFILLER_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09907_ _04035_ _04036_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__nor2_1
Xfanout532 net535 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_2
Xfanout510 net512 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_2
XFILLER_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout554 net2 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout543 net546 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__clkbuf_2
Xfanout565 net568 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__buf_2
XFILLER_100_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout587 net588 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__buf_2
XFILLER_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09838_ net322 net566 net560 net330 VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__a22o_1
XFILLER_46_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout598 net599 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__clkbuf_2
Xfanout576 net16 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__buf_2
XFILLER_58_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09769_ _03884_ _03885_ net163 net258 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_29_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10613_ _04799_ _04800_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__xnor2_1
XFILLER_10_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10544_ _04725_ _04726_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__xnor2_1
XFILLER_108_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10475_ _04651_ _04652_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__nor2_1
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05450_ _01758_ _01769_ _01824_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a21o_1
XFILLER_32_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05381_ _01017_ _01028_ _01082_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__nand3_1
XANTENNA_17 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net614 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07120_ _00863_ _00866_ _00994_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__nand3_1
X_07051_ net630 net288 VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__nand2_1
XFILLER_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06002_ _05114_ _05131_ _05132_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__and3_1
Xoutput124 net124 VGND VGND VPWR VPWR C[63] sky130_fd_sc_hd__buf_2
Xoutput113 net113 VGND VGND VPWR VPWR C[53] sky130_fd_sc_hd__buf_2
Xoutput102 net102 VGND VGND VPWR VPWR C[43] sky130_fd_sc_hd__buf_2
X_07953_ _01903_ _01904_ _01727_ _01729_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__o211a_1
XFILLER_101_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06904_ _00624_ _00763_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__and2b_1
X_07884_ _01828_ _01829_ _01830_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__nand3_1
XFILLER_28_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06835_ _00686_ _00687_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__and2b_1
XFILLER_83_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09623_ _03610_ _03612_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__or2_1
XFILLER_55_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06766_ _00472_ _00476_ _00610_ _00612_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__a211oi_2
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09554_ _03650_ _03651_ _03643_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__a21o_1
X_06697_ _00519_ _00533_ _00535_ VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__or3_1
X_08505_ _02486_ _02487_ _02507_ _02508_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__and4_1
XFILLER_24_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09485_ net385 net245 VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__nand2_1
X_05717_ net487 net494 net189 net431 VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__and4_1
X_08436_ net161 net363 net355 net170 VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__a22oi_2
XFILLER_11_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05648_ net494 net517 net189 net431 VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__and4_1
X_08367_ _02356_ _02357_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_34_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07318_ _01058_ _01064_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__nor2_1
X_05579_ _02632_ _03244_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__xnor2_1
X_08298_ _02277_ _02280_ _02281_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__nand3_1
X_07249_ net423 net174 VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__nand2_1
XFILLER_105_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10260_ _04417_ _04419_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__nand2_1
XFILLER_117_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10191_ net567 net285 _04343_ _04344_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__nand4_2
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout362 net363 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_4
Xfanout384 net390 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_93_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout373 net41 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__buf_4
XFILLER_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout351 net352 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_109_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout395 net39 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__buf_2
XFILLER_46_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput26 A[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xinput15 A[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput37 B[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xinput48 B[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
X_10527_ _04522_ _04707_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__nor2_1
Xinput59 B[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
XFILLER_6_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10458_ _04579_ _04584_ _04578_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10389_ _04481_ _04500_ _04480_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__a21oi_2
XFILLER_111_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06620_ _00450_ _00452_ _00449_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06551_ net491 net498 net364 net356 VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__and4_1
XFILLER_93_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06482_ _00302_ _00301_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__and2b_1
X_05502_ _01693_ _01714_ _01703_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__o21bai_1
X_09270_ _03342_ _03343_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__xnor2_1
X_08221_ _02194_ _02196_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__xnor2_1
X_05433_ _00669_ _01257_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__or2_1
XFILLER_33_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08152_ _01936_ _01943_ _01942_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__a21bo_1
X_05364_ _00778_ _00898_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__nand2_1
X_08083_ net608 net247 _01887_ _01886_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__a31o_1
X_07103_ net388 net402 VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__nand2_1
X_07034_ _00751_ _00753_ _00903_ _00904_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_95_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08985_ _03029_ _03030_ _03031_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__nand3_1
X_07936_ _01885_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__nor2_1
XFILLER_102_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07867_ net193 net578 _01810_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__a22o_1
XFILLER_56_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07798_ _01557_ _01559_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nor2_1
X_06818_ _00666_ _00667_ _00662_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__a21o_1
XFILLER_73_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09606_ _03689_ _03708_ _03709_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__and3_1
XFILLER_43_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06749_ _00591_ _00592_ _00584_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__a21o_1
X_09537_ net336 net569 VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_104_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09468_ _03555_ _03557_ _03434_ _03436_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__o211ai_1
X_08419_ _02241_ _02243_ _02411_ _02412_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__a211o_1
XFILLER_12_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09399_ _03464_ _03482_ _03484_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__nand3_2
XFILLER_22_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10312_ _04474_ _04475_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10243_ _04390_ _04401_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__nand2b_1
X_10174_ _04247_ _04249_ _04246_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__o21ba_1
Xfanout170 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_1
Xfanout192 net64 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08770_ _02797_ _02798_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__and2b_1
X_05982_ _05111_ _05112_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__and2b_1
XFILLER_38_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07721_ _01649_ _01651_ _01652_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__or3_1
XFILLER_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07652_ net465 net384 net362 net354 VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__and4_1
XFILLER_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06603_ net203 net180 net172 net211 VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__a22o_1
X_07583_ _01339_ _01342_ _01500_ _01502_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__a211oi_4
XFILLER_53_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06534_ _00356_ _00358_ _00231_ _00234_ VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__o211ai_2
X_09322_ _03393_ _03399_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__xnor2_1
X_06465_ _00268_ _00280_ _00282_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__or3_1
X_09253_ _03185_ _03188_ net152 _03324_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__a211oi_4
X_08204_ _02177_ _02178_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__xor2_1
X_06396_ _00213_ _00214_ _00215_ VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__nand3_1
X_09184_ _03247_ _03249_ _03107_ _03109_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__o211ai_2
X_05416_ _01431_ _01442_ _01453_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__a21o_1
X_08135_ _02102_ _02103_ _02104_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__or3_1
X_05347_ _00702_ _00713_ net254 net629 VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__and4bb_1
XFILLER_119_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08066_ _01868_ _02029_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__nand2_1
X_07017_ _00882_ _00883_ _00884_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__a21o_1
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08968_ _03011_ _03012_ _02898_ VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__a21o_1
X_07919_ _01699_ _01743_ _01742_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__a21bo_1
XFILLER_69_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08899_ _02749_ _02750_ _02748_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__a21bo_1
XFILLER_56_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_117_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10226_ net335 net322 net508 net502 VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__and4_1
XFILLER_79_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10157_ _04126_ _04222_ _04224_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__a21oi_1
X_10088_ _04145_ _04149_ _04229_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__a21boi_1
XFILLER_75_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06250_ net484 net403 VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06181_ net347 net164 net624 net440 VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_92_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap134 _02827_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
Xmax_cap156 _02775_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_1
X_09940_ _04072_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ _03995_ _03996_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__xor2_1
XFILLER_97_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08822_ _02854_ _02853_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__and2b_1
XFILLER_58_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08753_ _02613_ _02616_ _02778_ _02779_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__a211oi_2
XFILLER_57_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05965_ _05093_ _05094_ _05095_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__nand3_1
X_07704_ net208 net199 net580 net571 VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_49_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08684_ _02701_ _02702_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__xnor2_1
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05896_ _05019_ _05027_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__xor2_1
X_07635_ _01386_ _01389_ _01557_ _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__a211oi_1
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07566_ _01480_ _01483_ VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__xnor2_1
XFILLER_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06517_ _00209_ _00217_ _00216_ VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__a21bo_1
X_09305_ _03248_ _03250_ _03380_ _03381_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__a211oi_2
X_07497_ _01406_ _01407_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__and2b_1
X_09236_ net391 net374 net565 net556 VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__nand4_1
X_06448_ net631 net334 VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06379_ net197 net387 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__nand2_1
X_09167_ _03228_ _03229_ _03218_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08118_ _02084_ _02085_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__nor2_1
XFILLER_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09098_ net612 net328 net320 net619 VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__a22o_1
X_08049_ _02008_ _02009_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_112_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10011_ _04049_ _04052_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10209_ _04281_ _04283_ net136 _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__a211oi_2
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05750_ _04881_ _04882_ _04883_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_89_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05681_ _04331_ _04342_ _04320_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__o21ai_1
XFILLER_90_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07420_ _01323_ _01324_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__nor2_1
X_07351_ net483 net319 VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06302_ _00012_ _00015_ _00120_ _00122_ VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__a211oi_4
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07282_ _01172_ _01173_ _01174_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__nand3_1
X_06233_ net492 net397 net380 net499 VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__a22oi_1
X_09021_ _02848_ _02852_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_28_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06164_ _05206_ _05208_ _05207_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__o21ba_1
XFILLER_104_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06095_ _05205_ _05222_ _05223_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__nand3_2
X_09923_ _04051_ _04052_ _04053_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__and3_1
XFILLER_86_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09854_ _03857_ _03876_ _03979_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08805_ _02834_ _02835_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__xnor2_1
XFILLER_58_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_37_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06997_ _00857_ _00862_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__xnor2_1
X_09785_ net591 net583 net306 net291 VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__nand4_2
X_08736_ net392 net375 net594 net586 VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__nand4_1
X_05948_ _04994_ _05077_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__or2_1
X_08667_ _02376_ _02528_ _02527_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__a21oi_1
XFILLER_54_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05879_ _05010_ _05009_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__and2b_1
X_07618_ _01538_ _01539_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__nand2_1
XFILLER_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08598_ _02442_ _02450_ _02449_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__a21bo_1
X_07549_ _01462_ _01463_ _01299_ _01302_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_62_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10560_ net539 net243 VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__nand2_1
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10491_ _04625_ _04626_ _04622_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__a21o_1
X_09219_ net612 net597 net328 net320 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__and4_1
XFILLER_107_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06920_ _00776_ _00779_ _00775_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__a21oi_1
XFILLER_96_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06851_ _00703_ _00704_ _00557_ _00559_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__o211a_1
X_06782_ _00540_ _00542_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__or2_1
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09570_ _03598_ _03600_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__nand2_1
X_05802_ _04925_ _04933_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__xnor2_1
X_08521_ _02526_ _02525_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__and2b_1
XFILLER_82_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05733_ net472 net207 net460 net202 VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__and4_1
X_08452_ _02442_ _02449_ _02450_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__nand3_1
XFILLER_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07403_ _01162_ _01164_ _01303_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__nand3_1
XFILLER_51_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05664_ net472 net207 net202 net480 VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__a22oi_1
XFILLER_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08383_ _02372_ _02375_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__xnor2_1
X_05595_ _02687_ _02708_ _02676_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__o21ba_1
X_07334_ _01223_ _01229_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_21_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07265_ net194 net618 VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__nand2_1
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06216_ _00036_ _00037_ VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__nor2_1
X_09004_ _03039_ _03052_ _03053_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__nor3_4
XFILLER_117_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07196_ _01066_ _01078_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__xnor2_1
XFILLER_117_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06147_ _05272_ _05275_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__xnor2_1
X_06078_ net230 net300 net224 net239 VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__a22oi_1
Xfanout522 net23 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_4
Xfanout533 net535 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_2
Xfanout511 net512 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__buf_1
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_2
X_09906_ _03938_ _03942_ _04033_ _04034_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__a211oi_1
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout544 net545 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_2
Xfanout555 net561 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_4
Xfanout566 net567 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__buf_2
XFILLER_86_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09837_ net330 net322 net566 net560 VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__and4_1
Xfanout588 net589 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__buf_2
Xfanout577 net16 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__clkbuf_2
Xfanout599 net13 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09768_ net163 net258 _03884_ _03885_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_29_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08719_ net178 net170 net329 net321 VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_57_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09699_ _03803_ _03809_ _03811_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_107_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10612_ _04762_ _04768_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__nor2_1
X_10543_ _04681_ _04686_ _04679_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__a21oi_1
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10474_ _04607_ _04611_ _04650_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_29 _03265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_18 net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05380_ _01061_ _01071_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07050_ net520 net311 net295 net609 VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__a22o_1
XFILLER_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06001_ _05128_ _05129_ _05130_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_81_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput114 net114 VGND VGND VPWR VPWR C[54] sky130_fd_sc_hd__buf_2
Xoutput125 net125 VGND VGND VPWR VPWR C[6] sky130_fd_sc_hd__buf_2
Xoutput103 net103 VGND VGND VPWR VPWR C[44] sky130_fd_sc_hd__buf_2
XFILLER_114_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07952_ _01727_ _01729_ _01903_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__a211oi_1
XFILLER_99_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06903_ _00761_ _00762_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__and2b_1
XFILLER_95_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07883_ _01649_ _01652_ _01651_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__o21bai_1
X_06834_ net389 net418 net410 net469 VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__a22o_1
XFILLER_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09622_ _03726_ _03727_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_90_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09553_ _03643_ _03650_ _03651_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__nand3_1
X_06765_ _00542_ _00543_ _00608_ _00609_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__a2bb2oi_1
X_08504_ _02503_ _02504_ _02505_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_54_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06696_ _00519_ _00533_ _00535_ VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__nor3_1
XFILLER_51_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05716_ _04720_ _04730_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__or2_1
X_09484_ _03575_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08435_ net170 net161 net363 net355 VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__and4_1
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05647_ _03505_ _03526_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__nand2_1
X_08366_ _02094_ _02193_ _02192_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07317_ _01210_ _01212_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__nor2_1
X_05578_ _01682_ _02108_ net141 VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__a21oi_1
X_08297_ net162 net370 _02278_ _02279_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__nand4_1
X_07248_ _01133_ _01136_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__xnor2_1
X_07179_ _00773_ _01062_ _01060_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__o21a_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10190_ net567 net285 _04343_ _04344_ VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__a22o_1
XFILLER_78_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout341 net45 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__buf_2
XFILLER_105_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout330 net335 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout363 net42 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__buf_4
Xfanout352 net353 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout374 net375 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout396 net398 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkbuf_4
Xfanout385 net390 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_2
XFILLER_62_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 A[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_2
XFILLER_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 A[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_2
Xinput49 B[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_4
X_10526_ net283 net501 VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__nand2_1
Xinput38 B[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
X_10457_ _04632_ _04633_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__and2b_1
XFILLER_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10388_ _04540_ _04558_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06550_ net610 net631 net333 net326 VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__nand4_2
XFILLER_18_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06481_ _00179_ _00181_ _00180_ VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__o21ba_1
X_05501_ _02370_ _02380_ _02359_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__o21ai_1
XFILLER_33_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08220_ _02194_ _02196_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nand2_1
XFILLER_60_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05432_ _01268_ _01639_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__xor2_1
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08151_ _02120_ _02121_ _02113_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__a21o_1
X_05363_ _00800_ _00887_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__nand2_2
X_08082_ _02035_ _02046_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__xnor2_1
X_07102_ _00975_ _00976_ _00825_ _00827_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__o211a_1
X_07033_ _00900_ _00901_ _00794_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__o21ai_1
X_08984_ _03029_ _03030_ _03031_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__a21o_1
X_07935_ _01708_ _01711_ _01884_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__a21oi_1
XFILLER_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07866_ net209 net199 net571 net564 VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__nand4_1
X_09605_ _03706_ _03707_ _03594_ _03596_ VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_39_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07797_ _01733_ _01734_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__or2_1
X_06817_ _00662_ _00666_ _00667_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__nand3_1
XFILLER_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06748_ _00584_ _00591_ _00592_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__nand3_1
X_09536_ net351 net562 net555 net359 VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_104_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09467_ _03434_ _03436_ _03555_ _03557_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__a211o_1
X_06679_ _00507_ _00515_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__nor2_1
X_08418_ _02241_ _02243_ _02411_ _02412_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__a211oi_1
XFILLER_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09398_ _03480_ _03481_ _03360_ _03362_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__a211o_1
X_08349_ _02334_ _02338_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10311_ _04474_ _04475_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__or2_1
XFILLER_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10242_ _04391_ _04400_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_115_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10173_ _04324_ _04325_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__xnor2_1
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_2
Xfanout171 net8 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
Xfanout160 net163 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_2
XFILLER_47_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10509_ net278 net270 net523 net507 VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__and4_1
XFILLER_10_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07720_ net344 net529 net513 net437 VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__a22oi_2
X_05981_ _05109_ _05110_ _05106_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__a21o_1
XFILLER_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07651_ net548 net340 VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__nand2_1
XFILLER_93_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06602_ net211 net203 net180 net172 VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__nand4_1
X_07582_ _01498_ _01499_ _01479_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__a21oi_2
XFILLER_53_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06533_ _00231_ _00234_ _00356_ _00358_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__a211o_1
X_09321_ _03397_ _03398_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__xnor2_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06464_ _00268_ _00280_ _00282_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__nor3_1
XFILLER_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09252_ _03320_ _03322_ _03147_ _03151_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__o211a_1
X_08203_ _02177_ _02178_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__and2b_1
X_09183_ _03107_ _03109_ _03247_ _03249_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__a211o_1
X_06395_ _00107_ _00109_ _00108_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__o21bai_1
X_05415_ _01431_ _01442_ _01453_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__nand3_2
X_08134_ net179 net363 net355 net221 VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__a22oi_2
X_05346_ net439 net518 net606 net346 VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__a22oi_1
XFILLER_119_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08065_ _02026_ _02027_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__xor2_2
XFILLER_115_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07016_ _00882_ _00883_ _00884_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__nand3_2
XFILLER_102_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08967_ _02898_ _03011_ _03012_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__nand3_2
X_07918_ net630 net247 _01716_ _01715_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__a31o_1
XFILLER_75_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08898_ _02934_ _02935_ _02936_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__nand3_1
X_07849_ net184 net427 net594 net585 VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__and4_1
XFILLER_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09519_ _03612_ _03613_ _03495_ _03497_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__o211a_1
XFILLER_44_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10225_ _04381_ _04382_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__xnor2_1
X_10156_ _04306_ _04307_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__nand2b_1
XFILLER_94_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10087_ _04231_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__inv_2
XFILLER_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06180_ net440 net347 net164 net624 VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_92_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap135 _01671_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_1
Xmax_cap146 _00893_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_1
Xmax_cap157 _02615_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_1
X_09870_ _03995_ _03996_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__or2_1
XFILLER_112_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08821_ _02696_ _02700_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__nor2_1
XFILLER_112_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08752_ _02775_ _02777_ _02641_ _02644_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__o211a_1
XFILLER_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05964_ net488 net425 _05006_ _05005_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__a31o_1
XFILLER_38_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08683_ _02702_ _02701_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__and2b_1
X_07703_ net193 net585 VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__nand2_1
XFILLER_66_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07634_ _01555_ _01556_ _01545_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_49_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05895_ _05025_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__and2b_1
XFILLER_65_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07565_ _01481_ _01482_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__nor2_1
XFILLER_34_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07496_ net451 net332 net324 net458 VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_101_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06516_ _00337_ _00338_ _00329_ VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__a21o_1
X_09304_ _03378_ _03379_ _03240_ _03242_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__o211a_1
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06447_ _00263_ _00264_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__xnor2_1
XFILLER_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09235_ net399 net556 _03131_ _03130_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__a31o_1
XFILLER_21_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06378_ _00196_ _00197_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__nor2_1
X_09166_ _03218_ _03228_ _03229_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__nand3_1
XFILLER_107_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08117_ _02082_ _02083_ _01898_ _01901_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__o211a_1
XFILLER_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09097_ net619 net612 net328 net320 VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__and4_1
X_05329_ net257 net605 VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__nand2_1
X_08048_ _02008_ _02009_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_112_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10010_ net338 net530 _04145_ _04147_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__nand4_2
XFILLER_103_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09999_ _04134_ _04135_ _04137_ _03267_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__a22oi_4
XFILLER_29_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10208_ _04361_ _04362_ _04242_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__o21a_1
X_10139_ _04285_ _04286_ _04198_ _04202_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__a211oi_1
XFILLER_94_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05680_ _04320_ _04331_ _04342_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__or3_1
XFILLER_50_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07350_ _01244_ _01247_ _01085_ _01088_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__o211ai_2
XFILLER_50_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06301_ _00118_ _00119_ _00101_ VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__a21oi_2
X_09020_ _03070_ _03071_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__nor2_1
X_07281_ net344 net559 net544 net438 VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__a22o_1
X_06232_ net492 net499 net397 net380 VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__and4_1
X_06163_ _05197_ _05199_ _05198_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__o21ba_1
XFILLER_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06094_ _05205_ _05222_ _05223_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__and3_1
X_09922_ _03967_ _03970_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__nand2_1
X_09853_ _03977_ _03978_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__nand2_1
XFILLER_112_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08804_ _02835_ _02834_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__and2b_1
X_09784_ net583 net313 _03760_ _03759_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__a31o_1
XFILLER_105_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06996_ _00857_ _00862_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__nand2b_1
XFILLER_73_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08735_ net401 net585 _02626_ _02625_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__a31o_1
XFILLER_54_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05947_ _04994_ _05077_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nand2_1
XFILLER_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08666_ _02536_ _02683_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__xnor2_1
X_05878_ _04927_ _04929_ _04926_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__o21ba_1
X_07617_ net630 net252 _01537_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__a21o_1
X_08597_ _02606_ _02607_ _02600_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__a21o_1
X_07548_ _01299_ _01302_ _01462_ _01463_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__o211ai_2
XFILLER_81_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07479_ _01379_ _01388_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_101_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10490_ _04668_ _04669_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__nor2_1
X_09218_ _03285_ _03286_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__or2_1
XFILLER_108_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09149_ _03074_ _03077_ _03210_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__a21o_1
XFILLER_89_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_110_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06850_ _00557_ _00559_ _00703_ _00704_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__a211oi_2
XFILLER_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05801_ _04925_ _04933_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__and2_1
XFILLER_95_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06781_ _00628_ _00629_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__xnor2_1
X_08520_ _02212_ _02360_ _02358_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__a21oi_1
X_05732_ _04266_ _04288_ _04277_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__o21ba_1
X_08451_ _02447_ _02448_ _02443_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a21o_1
X_05663_ net480 net472 net207 net202 VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__and4_1
X_07402_ _01162_ _01164_ _01303_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__a21o_1
XFILLER_63_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08382_ _02046_ _02374_ _02373_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__o21ai_1
X_05594_ _03395_ _03406_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__nor2_1
X_07333_ _01223_ _01229_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_21_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07264_ _01013_ _01015_ _01014_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__o21ba_1
X_06215_ _05243_ _00035_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__nor2_1
X_09003_ _03049_ _03050_ _03051_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__a21oi_2
X_07195_ _01066_ _01078_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__and2b_1
X_06146_ _05273_ _05274_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__nor2_1
X_06077_ net239 net230 net300 net224 VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__and4_1
Xwire3 _01664_ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_1
Xfanout523 net22 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__clkbuf_4
Xfanout501 net502 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__clkbuf_2
X_09905_ _04033_ _04034_ _03938_ _03942_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__o211a_1
Xfanout512 net515 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_58_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout545 net546 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkbuf_2
Xfanout534 net535 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__buf_1
Xfanout556 net558 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__buf_2
XFILLER_100_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout578 net579 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__buf_2
Xfanout589 net15 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_4
X_09836_ _03854_ _03958_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__xnor2_1
Xfanout567 net568 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06979_ _00843_ _00845_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__and2_1
XFILLER_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09767_ net612 net274 net265 net620 VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a22oi_1
XFILLER_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08718_ _02738_ _02739_ _02574_ _02578_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__a211oi_1
XFILLER_73_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09698_ _03807_ _03808_ _03804_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__a21o_1
X_08649_ _02663_ _02664_ _02506_ _02509_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__a211oi_1
XFILLER_54_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10611_ _04797_ _04798_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nor2_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10542_ _04723_ _04724_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__and2_1
XFILLER_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10473_ _04607_ _04611_ _04650_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__and3_1
XFILLER_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_19 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06000_ _05128_ _05129_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_97_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput115 net115 VGND VGND VPWR VPWR C[55] sky130_fd_sc_hd__buf_2
Xoutput104 net104 VGND VGND VPWR VPWR C[45] sky130_fd_sc_hd__buf_2
Xoutput126 net126 VGND VGND VPWR VPWR C[7] sky130_fd_sc_hd__buf_2
X_07951_ _01901_ _01902_ _01891_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__a21oi_1
X_06902_ _00759_ _00760_ _00618_ _00621_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__a211o_1
X_07882_ _01826_ _01827_ _01825_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__a21o_1
XFILLER_95_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06833_ net469 net389 net418 net410 VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__and4_1
X_09621_ _03722_ _03725_ _03604_ _03606_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__o211ai_1
X_06764_ _00542_ _00543_ _00608_ _00609_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__or4bb_1
XFILLER_83_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09552_ _03648_ _03649_ _03644_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__a21o_1
XFILLER_83_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08503_ _02503_ _02504_ _02505_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_54_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05715_ net605 net628 net420 net412 VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__and4_1
X_06695_ _00397_ _00399_ _00532_ VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__and3_1
XFILLER_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09483_ _03455_ _03456_ _03454_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__a21oi_1
X_08434_ net178 net340 VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand2_1
XFILLER_51_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05646_ _03962_ _03973_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__xor2_1
X_08365_ _02257_ _02355_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05577_ _03211_ _03222_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__nor2_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07316_ _01211_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__inv_2
X_08296_ net162 net370 _02278_ _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__a22o_1
X_07247_ _01134_ _01135_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__nor2_1
XFILLER_117_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07178_ _00765_ _00912_ _00914_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__or3_1
XFILLER_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06129_ _05256_ _05257_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout331 net335 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_2
Xfanout364 net365 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__buf_2
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__buf_2
Xfanout353 net43 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_109_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout397 net398 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__clkbuf_2
Xfanout386 net390 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__buf_2
XFILLER_19_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09819_ _03937_ _03939_ _03940_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__o21ai_1
XFILLER_14_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput28 A[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
Xinput17 A[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
Xinput39 B[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
XFILLER_10_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10525_ _04704_ _04705_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__xnor2_1
X_10456_ _04569_ _04573_ _04631_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__a21o_1
X_10387_ _04556_ _04557_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06480_ _00299_ _00300_ VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__xnor2_1
X_05500_ _02359_ _02370_ _02380_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__or3_1
XFILLER_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05431_ _01617_ _01628_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__nand2_1
X_08150_ _02113_ _02120_ _02121_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_31_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07101_ _00825_ _00827_ _00975_ _00976_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__a211oi_2
X_05362_ _00822_ _00876_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__and2_1
XFILLER_119_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08081_ _02046_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__inv_2
XFILLER_106_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07032_ _00794_ _00900_ _00901_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_11_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08983_ net614 net336 VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__and2_1
X_07934_ _01708_ _01711_ _01884_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__and3_1
XFILLER_102_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07865_ net199 net571 net564 net208 VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__a22o_1
XFILLER_83_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09604_ _03594_ _03596_ _03706_ _03707_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_39_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07796_ _01731_ _01732_ _01553_ _01555_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__o211a_1
X_06816_ _00663_ _00664_ _00665_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__a21bo_1
X_06747_ _00588_ _00589_ _00590_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__a21o_1
X_09535_ net359 net351 net562 net555 VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__nand4_1
XFILLER_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06678_ _00507_ _00515_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_104_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09466_ _03553_ _03554_ _03401_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__a21oi_1
X_08417_ _02409_ _02410_ _02399_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05629_ _03417_ _03777_ _03788_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__and3_1
XFILLER_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09397_ _03360_ _03362_ _03480_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__o211ai_4
X_08348_ _02335_ _02336_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__and2b_1
X_08279_ _02259_ _02261_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__and2b_1
XFILLER_20_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10310_ _04391_ _04400_ _04399_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__a21oi_1
XFILLER_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10241_ _04392_ _04398_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__xnor2_1
XFILLER_3_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_115_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10172_ net583 net262 VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__nand2_1
XFILLER_78_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout183 net7 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_2
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
Xfanout172 net175 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_2
XFILLER_47_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout194 net197 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_47_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10508_ net266 net507 VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__nand2_1
XFILLER_7_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10439_ _04547_ _04552_ _04612_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__a21oi_1
XFILLER_88_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05980_ _05106_ _05109_ _05110_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__and3_1
XFILLER_111_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07650_ _01574_ _01575_ VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__xnor2_2
XFILLER_65_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07581_ _01479_ _01498_ _01499_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__nand3_2
X_06601_ _00325_ _00327_ _00326_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_36_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06532_ _00289_ _00290_ _00354_ _00355_ VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__a2bb2oi_1
X_09320_ net399 net532 VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09251_ _03147_ _03151_ _03320_ _03322_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__a211oi_1
X_06463_ _00160_ _00162_ _00279_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__and3_1
X_08202_ _01996_ _02003_ _02002_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__a21bo_1
XFILLER_119_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06394_ _00211_ _00212_ _00210_ VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__o21ai_1
X_09182_ _03245_ _03246_ _03065_ _03112_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__o211a_1
X_05414_ _01028_ _01082_ _01017_ VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__a21bo_1
X_08133_ net221 net179 net363 net355 VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__and4_1
X_05345_ net436 net343 net516 net606 VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__and4_1
X_08064_ _02026_ _02027_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__or2_1
XFILLER_119_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07015_ _00723_ _00732_ _00731_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__a21bo_1
XFILLER_115_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08966_ _03009_ _03010_ _03000_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__a21o_1
X_07917_ _01865_ _01866_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__xnor2_1
X_08897_ _02934_ _02935_ _02936_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__a21o_1
X_07848_ net422 net601 VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__nand2_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07779_ _01713_ _01715_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__nor2_1
X_09518_ _03495_ _03497_ _03612_ _03613_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_65_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09449_ net399 net532 _03396_ _03394_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__a31o_1
XFILLER_12_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10224_ _04307_ _04312_ _04306_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__a21oi_1
X_10155_ _04304_ _04305_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__nand2_1
XFILLER_58_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10086_ _04145_ _04149_ _04230_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__nand3_1
XFILLER_75_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap147 _00469_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_1
Xmax_cap158 net635 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_2
Xmax_cap136 _04363_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_1
X_08820_ _02851_ _02852_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__nor2_1
XFILLER_112_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08751_ _02641_ _02644_ net156 _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__a211oi_4
X_05963_ _05090_ _05091_ _05092_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__nand3_1
X_08682_ _02540_ _02543_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__nor2_1
X_07702_ _01480_ _01482_ _01481_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__o21bai_1
X_05894_ _05023_ _05024_ _05020_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__a21o_1
X_07633_ _01545_ _01555_ _01556_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__and3_1
XFILLER_66_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07564_ net226 net568 net559 net236 VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__a22oi_1
X_07495_ net458 net451 net332 net324 VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_101_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06515_ _00329_ _00337_ _00338_ VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__nand3_1
X_09303_ _03240_ _03242_ _03378_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__a211oi_2
X_06446_ _00264_ _00263_ VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09234_ _03174_ _03177_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand2_1
X_09165_ _03218_ _03228_ _03229_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__and3_1
XFILLER_119_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08116_ _01898_ _01901_ _02082_ _02083_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__a211oi_1
X_06377_ net204 net301 net223 net212 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__a22oi_1
XFILLER_119_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09096_ _03018_ _03152_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__xor2_1
X_05328_ net436 net343 net493 net516 VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__and4_1
XFILLER_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08047_ _01818_ _01838_ _01837_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__a21bo_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09998_ _03265_ _04134_ VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__and2_1
X_08949_ _02858_ _02859_ _02863_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__o21a_1
XFILLER_48_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10207_ _04242_ _04361_ _04362_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__nor3_1
XFILLER_94_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10138_ _04287_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__inv_2
X_10069_ _04104_ _04106_ _04211_ _04213_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_89_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06300_ _00101_ _00118_ _00119_ VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__nand3_2
X_07280_ net438 net344 net559 net544 VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__nand4_1
X_06231_ _05272_ _05274_ _05273_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__o21ba_1
X_06162_ _05287_ _05288_ _05271_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__a21oi_1
X_06093_ _05219_ _05220_ _05221_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__a21o_1
XFILLER_116_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09921_ net337 net536 _04049_ _04050_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__nand4_1
X_09852_ _03960_ _03976_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__or2_1
XFILLER_112_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08803_ _02537_ _02678_ _02677_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__a21oi_1
X_09783_ _03805_ _03808_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__nand2_1
X_06995_ _00858_ _00861_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__xnor2_1
X_08734_ _02602_ _02605_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__nand2_1
XFILLER_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05946_ _05075_ _05076_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__nor2_1
X_08665_ _02536_ _02683_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__nand2_1
X_05877_ _05007_ _05008_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__xnor2_1
XFILLER_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07616_ net630 net252 _01537_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__nand3_1
XFILLER_81_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08596_ _02600_ _02606_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__nand3_1
X_07547_ _01460_ _01461_ _01445_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__a21o_1
XFILLER_54_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07478_ _01380_ _01385_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__xnor2_1
XFILLER_22_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06429_ _00248_ VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__inv_2
XFILLER_6_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09217_ _03141_ _03143_ _03284_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__nor3_1
XFILLER_108_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09148_ _03074_ _03077_ _03210_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__and3_1
XFILLER_108_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09079_ net188 net430 net509 net504 VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__nand4_2
XFILLER_77_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05800_ _04930_ _04931_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__xnor2_1
X_06780_ _00492_ _00494_ _00491_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__o21ba_1
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05731_ _04179_ _04201_ _04168_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__o21ba_1
XFILLER_36_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08450_ _02443_ _02447_ _02448_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__nand3_1
X_05662_ _03548_ _03570_ _03559_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__o21ba_1
X_08381_ _02035_ _02209_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__nand2_1
X_07401_ _01162_ _01164_ _01303_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07332_ _01227_ _01228_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__xnor2_1
X_05593_ _02730_ _02752_ _03385_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_21_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07263_ _01003_ _01005_ _01004_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__o21ba_1
X_07194_ _01067_ _01076_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__xor2_1
X_06214_ _05243_ _00035_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__and2_1
X_09002_ _03049_ _03050_ _03051_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__and3_2
X_06145_ net476 net419 net411 net484 VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__a22oi_1
X_06076_ net216 net386 VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__nand2_1
Xfanout502 net25 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__buf_2
Xfanout524 net22 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__clkbuf_2
X_09904_ _04031_ _04032_ _03896_ _03900_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__o211a_1
Xfanout513 net515 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout557 net558 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__buf_2
Xfanout546 net20 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__buf_2
Xfanout535 net538 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__clkbuf_2
X_09835_ _03854_ _03958_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__nand2_1
Xfanout568 net18 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__clkbuf_2
Xfanout579 net582 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__buf_2
XFILLER_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06978_ _00692_ _00695_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__nand2_1
XFILLER_73_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09766_ net620 net612 net274 net265 VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_29_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08717_ _02574_ _02578_ _02738_ _02739_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__o211a_1
X_09697_ _03804_ _03807_ _03808_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__nand3_2
X_05929_ _04977_ _04979_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__nand2_1
X_08648_ _02506_ _02509_ _02663_ _02664_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__o211a_1
XFILLER_54_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08579_ net621 net363 net355 net161 VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__a22o_1
XFILLER_25_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10610_ _04755_ _04759_ _04794_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10541_ _04673_ _04675_ _04722_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10472_ _04648_ _04649_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput116 net116 VGND VGND VPWR VPWR C[56] sky130_fd_sc_hd__buf_2
Xoutput105 net105 VGND VGND VPWR VPWR C[46] sky130_fd_sc_hd__buf_2
XFILLER_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput127 net127 VGND VGND VPWR VPWR C[8] sky130_fd_sc_hd__buf_2
X_07950_ _01891_ _01901_ _01902_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__and3_1
X_06901_ _00618_ _00621_ _00759_ _00760_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__o211a_1
XFILLER_87_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07881_ _01825_ _01826_ _01827_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__nand3_1
XFILLER_95_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06832_ _00567_ _00576_ _00575_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__a21o_1
XFILLER_55_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09620_ _03604_ _03606_ _03722_ _03725_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__a211o_1
X_06763_ _00542_ _00543_ _00608_ _00609_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__and4bb_1
X_09551_ _03644_ _03648_ _03649_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__nand3_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08502_ _02503_ _02504_ _02505_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_54_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05714_ net604 net420 net412 net628 VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__a22oi_1
XFILLER_36_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06694_ _00533_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__inv_2
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09482_ _03573_ _03574_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08433_ _02428_ _02429_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__xnor2_1
X_05645_ _03222_ _03276_ _03211_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__o21bai_1
X_08364_ _02352_ _02353_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__xnor2_1
X_05576_ _02643_ _03189_ _03200_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_34_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07315_ _01208_ _01209_ _01055_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__or3b_1
XFILLER_32_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08295_ net378 net621 net615 net394 VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__a22o_1
X_07246_ net409 net222 net182 net417 VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__a22oi_1
X_07177_ _00764_ _00913_ _00914_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06128_ net610 net371 VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__nand2_1
XFILLER_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06059_ _05186_ _05187_ _05179_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__a21o_1
Xfanout332 net335 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_2
Xfanout310 net311 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout321 net323 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout354 net355 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkbuf_4
Xfanout365 net42 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__clkbuf_2
Xfanout343 net349 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout387 net390 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__buf_1
X_09818_ _03937_ _03939_ _03940_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__or3_1
Xfanout376 net382 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout398 net39 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkbuf_2
X_09749_ net351 net543 net535 net359 VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__a22o_1
XFILLER_54_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput18 A[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_2
Xinput29 A[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
X_10524_ net555 net243 VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__nand2_1
XFILLER_108_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10455_ _04569_ _04573_ _04631_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__and3_1
XFILLER_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10386_ net577 net244 VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__nand2_1
XFILLER_89_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05430_ _01595_ _01606_ _01246_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__a21o_1
XFILLER_21_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05361_ _00844_ _00865_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__and2_1
XFILLER_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07100_ net153 _00974_ _00851_ _00854_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__o211a_1
XFILLER_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08080_ _02041_ _02044_ _02045_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__and3_2
X_07031_ _00794_ _00900_ _00901_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_11_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08982_ net350 net598 net592 net358 VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__a22o_1
XFILLER_114_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07933_ _01881_ _01882_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__xor2_1
XFILLER_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07864_ _01644_ _01646_ _01645_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__o21bai_1
XFILLER_113_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06815_ _00665_ _00664_ _00663_ VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__nand3b_1
XFILLER_83_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09603_ _03703_ _03705_ _03589_ _03591_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__o211ai_2
X_07795_ _01553_ _01555_ _01731_ _01732_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__a211oi_1
XFILLER_56_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06746_ _00588_ _00589_ _00590_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__nand3_1
X_09534_ _03629_ _03630_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__xnor2_1
X_06677_ _00512_ _00513_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_19_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09465_ _03401_ _03553_ _03554_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_104_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08416_ _02399_ _02409_ _02410_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__and3_1
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05628_ _03755_ _03766_ _02949_ _02982_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__o211ai_2
X_09396_ _03477_ _03479_ _03356_ _03358_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__o211ai_4
X_08347_ net227 net511 net503 net236 VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__a22o_1
XFILLER_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05559_ net604 net627 net189 net431 VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__and4_1
X_08278_ net298 net331 net324 net383 VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__a22o_1
XFILLER_22_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07229_ net388 net394 net378 net470 VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__a22oi_1
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10240_ _04392_ _04398_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__and2b_1
XFILLER_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_115_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10171_ _04322_ _04323_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout173 net175 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout184 net186 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_2
Xfanout195 net196 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
XFILLER_86_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10507_ net563 net244 _04653_ _04652_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_94_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10438_ _04547_ _04552_ _04612_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__and3_1
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10369_ _04476_ _04536_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__nor2_1
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06600_ net196 net301 _00317_ _00315_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__a31o_1
X_07580_ _01479_ _01498_ _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_36_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06531_ _00289_ _00290_ _00354_ _00355_ VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__or4bb_1
XFILLER_33_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09250_ _03316_ _03318_ _03303_ VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__o21a_1
X_06462_ _00280_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__inv_2
X_08201_ _02175_ _02176_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_16_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06393_ _00210_ _00211_ _00212_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__or3_1
X_09181_ _03065_ _03112_ _03245_ _03246_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__a211o_1
X_05413_ _01355_ _01366_ _01420_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__a21o_1
XFILLER_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08132_ net299 net340 VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__nand2_1
X_05344_ _00527_ _00549_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__xnor2_1
X_08063_ _01698_ _01855_ _01854_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__a21boi_2
XFILLER_108_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07014_ _00880_ _00881_ _00872_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__a21o_1
XFILLER_115_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08965_ _03000_ _03009_ _03010_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__nand3_1
X_07916_ _01692_ _01697_ _01691_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__o21bai_1
XFILLER_102_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08896_ net621 net337 VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__and2_1
X_07847_ _01786_ _01789_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07778_ _01536_ _01538_ _01712_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__a21oi_1
XFILLER_44_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06729_ _00569_ _00570_ _00572_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__or3_1
X_09517_ _03610_ _03611_ _03487_ _03489_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_65_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09448_ _03423_ _03426_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__nand2_1
X_09379_ _03460_ _03462_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_117_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10223_ _04379_ _04380_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__nor2_1
XFILLER_79_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10154_ _04304_ _04305_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__nor2_1
XFILLER_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10085_ _04047_ _04227_ _04228_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__o21ai_1
XFILLER_75_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap148 _00350_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_1
Xmax_cap137 _04204_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
XFILLER_112_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08750_ _02771_ _02773_ _02758_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__o21a_1
X_05962_ _05090_ _05091_ _05092_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__a21o_1
XFILLER_38_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08681_ _02699_ _02700_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__nor2_1
X_07701_ _01471_ _01473_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__nand2_1
XFILLER_66_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05893_ _05020_ _05023_ _05024_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__and3_1
X_07632_ _01553_ _01554_ _01546_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__a21o_1
XFILLER_93_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07563_ net236 net226 net568 net559 VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__and4_1
X_09302_ _03376_ _03377_ _03197_ _03245_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07494_ _01279_ _01281_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__nor2_1
X_06514_ _00334_ _00335_ _00336_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__a21o_1
X_06445_ net631 net339 _00147_ _00145_ VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__a31oi_2
X_09233_ _03292_ _03302_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__xnor2_1
X_09164_ _03226_ _03227_ _03219_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__a21o_1
X_08115_ _02080_ _02081_ _02070_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__a21oi_1
X_06376_ net212 net204 net301 net223 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__and4_1
XFILLER_119_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09095_ _03018_ _03152_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__nor2_1
X_05327_ _00353_ _00374_ _00364_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__o21ai_1
XFILLER_107_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08046_ _01991_ _02007_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_112_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09997_ _03259_ _03392_ _03738_ _04131_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__or4_4
X_08948_ _02989_ _02992_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__xnor2_1
X_08879_ _02914_ _02915_ _02907_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__a21o_1
XFILLER_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10206_ _04358_ _04360_ _04338_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10137_ _04198_ _04202_ _04285_ _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10068_ _04209_ _04210_ _04108_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_89_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06230_ net610 net371 _05256_ _05254_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06161_ _05271_ _05287_ _05288_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__nand3_1
X_06092_ _05219_ _05220_ _05221_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__nand3_4
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09920_ net337 net536 _04049_ _04050_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__a22o_1
X_09851_ _03960_ _03976_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__nand2_1
XFILLER_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08802_ _02695_ _02833_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__xor2_1
X_06994_ _00859_ _00860_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__nor2_1
X_09782_ _03763_ _03772_ _03771_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ _02747_ _02757_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__xnor2_1
X_05945_ _05073_ _05074_ _04999_ _05003_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__a211oi_1
XFILLER_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08664_ _02680_ _02681_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__xor2_1
XFILLER_66_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05876_ net488 net425 VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__nand2_1
XFILLER_26_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07615_ _01534_ _01535_ VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__xnor2_1
X_08595_ _02604_ _02605_ _02601_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__a21o_1
XFILLER_54_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07546_ _01445_ _01460_ _01461_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nand3_2
XFILLER_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07477_ _01380_ _01385_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__nand2b_1
XFILLER_22_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09216_ _03141_ _03143_ _03284_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__o21a_1
X_06428_ _00139_ _00246_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__xor2_1
XFILLER_108_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06359_ net448 net426 VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__nand2_1
X_09147_ _03208_ _03209_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__xnor2_1
XFILLER_108_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09078_ _03132_ _03133_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08029_ _01987_ _01989_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__and2b_1
XFILLER_1_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_24_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05730_ _04856_ _04862_ _04070_ _04092_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__o211a_1
XFILLER_35_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05661_ _03461_ _03483_ _03450_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__o21ba_1
XFILLER_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08380_ _02034_ _02205_ _02208_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__a21o_1
X_07400_ _01292_ _01301_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__xnor2_1
XFILLER_63_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07331_ net519 net288 VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__nand2_1
XFILLER_51_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05592_ _02730_ _02752_ _03385_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_21_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07262_ _01150_ _01151_ _00991_ _00993_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_51_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07193_ _01067_ _01076_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__nand2_1
X_09001_ _02945_ _02953_ _02952_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__a21bo_1
X_06213_ _05241_ _00033_ VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__xnor2_1
X_06144_ net484 net476 net419 net411 VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__and4_1
XFILLER_105_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06075_ _05195_ _05203_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__xor2_1
XFILLER_116_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout503 net506 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_2
X_09903_ _03896_ _03900_ _04031_ _04032_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__a211oi_2
Xfanout514 net515 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout547 net548 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_60_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__buf_2
Xfanout525 net528 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__buf_2
X_09834_ _03956_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__and2_1
XFILLER_112_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout569 net17 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__buf_2
Xfanout558 net561 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__buf_2
XFILLER_100_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06977_ _00841_ _00842_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__nor2_1
X_09765_ _03882_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08716_ _02735_ _02736_ _02618_ _02620_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__a211o_1
X_09696_ net613 net283 _03805_ _03806_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__nand4_2
X_05928_ _05058_ _05059_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__or2_1
XFILLER_39_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08647_ _02644_ _02645_ _02661_ _02662_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05859_ _04914_ _04987_ _04990_ _04916_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08578_ net161 net621 net363 net355 VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__nand4_1
X_07529_ _01440_ _01441_ _01405_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__o21a_1
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10540_ _04673_ _04675_ _04722_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__or3_1
XFILLER_22_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10471_ _04646_ _04647_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__nand2_1
XFILLER_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10669_ _03266_ _04857_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_97_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput106 net106 VGND VGND VPWR VPWR C[47] sky130_fd_sc_hd__buf_2
Xoutput117 net117 VGND VGND VPWR VPWR C[57] sky130_fd_sc_hd__buf_2
Xoutput128 net128 VGND VGND VPWR VPWR C[9] sky130_fd_sc_hd__buf_2
XFILLER_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06900_ _00756_ _00758_ _00500_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__a21o_1
XFILLER_68_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07880_ net437 net344 net513 net505 VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__nand4_1
X_06831_ _00681_ _00682_ _00534_ _00537_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__o211a_1
XFILLER_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06762_ _00606_ _00607_ _00467_ _00469_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__a211o_1
XFILLER_83_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09550_ net367 net543 _03645_ _03647_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__nand4_1
X_08501_ _02331_ _02332_ _02341_ _02340_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__a31o_1
X_09481_ net297 net248 VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__and2_1
X_05713_ _03994_ _04092_ _04103_ _04125_ _03363_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__a32oi_2
XFILLER_36_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06693_ _00397_ _00399_ _00532_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__a21oi_2
X_08432_ net383 net316 VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__nand2_1
X_05644_ _03297_ _03941_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__xor2_1
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08363_ _02353_ _02352_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__and2b_1
X_05575_ _03189_ _03200_ _02643_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__a21oi_1
X_07314_ _01208_ _01209_ _01055_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__o21ba_1
X_08294_ net394 net378 net622 net615 VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_34_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07245_ net417 net409 net222 net182 VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__and4_1
X_07176_ _00910_ _01057_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__xnor2_1
X_06127_ _05254_ _05255_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__nor2_1
XFILLER_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06058_ _05179_ _05186_ _05187_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__nand3_1
Xfanout311 net49 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__buf_2
Xfanout300 net303 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_2
Xfanout322 net323 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout355 net43 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__buf_4
XFILLER_113_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout333 net334 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout344 net345 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_2
Xfanout366 net367 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout388 net390 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_2
XFILLER_86_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout377 net378 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_2
X_09817_ _03795_ _03796_ _03800_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__o21a_1
Xfanout399 net400 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__buf_2
XFILLER_101_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09748_ net359 net351 net543 net535 VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__nand4_1
XFILLER_74_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09679_ _03787_ _03789_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__nor2_1
XFILLER_54_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10523_ _04702_ _04703_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__nor2_1
Xinput19 A[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
X_10454_ _04629_ _04630_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__xnor2_1
X_10385_ _04554_ _04555_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__nor2_1
XFILLER_96_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05360_ net346 net606 net65 VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_31_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07030_ _00897_ _00899_ _00747_ net633 VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_11_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08981_ net358 net350 net598 net592 VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand4_1
X_07932_ net519 net252 _01881_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__nand3_1
XFILLER_87_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07863_ _01635_ _01637_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__nand2_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06814_ net461 net371 VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__nand2_1
X_09602_ _03589_ _03591_ _03703_ _03705_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__a211o_1
XFILLER_28_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07794_ _01729_ _01730_ _01719_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__a21oi_1
X_09533_ net590 net312 VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_39_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06745_ _00449_ _00452_ _00450_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__o21bai_1
X_06676_ _00512_ _00513_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_19_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09464_ _03401_ _03553_ _03554_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__and3_1
XFILLER_36_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08415_ _02407_ _02408_ _02400_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__a21o_1
XFILLER_12_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09395_ _03356_ _03358_ _03477_ _03479_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__a211o_2
X_05627_ _02949_ _02982_ _03755_ _03766_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__a211o_1
X_08346_ net236 net227 net510 net503 VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__and4_1
X_05558_ net604 net189 net431 net627 VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__a22oi_1
X_08277_ net383 net298 net331 net324 VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__and4_1
X_05489_ _01911_ _01933_ _01900_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__o21ba_1
XFILLER_22_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07228_ net470 net388 net394 net378 VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__and4_1
X_07159_ _00891_ net146 _01038_ _01040_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__o211a_2
XFILLER_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10170_ net569 net276 net269 net577 VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__a22oi_1
XFILLER_87_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_2
Xfanout163 net167 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_2
XFILLER_47_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout196 net197 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10506_ _04681_ _04686_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__xor2_1
XFILLER_109_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10437_ _04610_ _04611_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__nand2_1
XFILLER_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10368_ _04476_ _04536_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__and2_1
XFILLER_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10299_ _04462_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__inv_2
XFILLER_65_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06530_ _00289_ _00290_ _00354_ _00355_ VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__and4bb_1
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06461_ _00160_ _00162_ _00279_ VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__a21oi_2
XFILLER_61_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08200_ _02172_ _02174_ _02168_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_16_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05412_ _01355_ _01366_ _01420_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__nand3_1
XFILLER_33_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09180_ _03065_ _03112_ _03245_ _03246_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__a211oi_1
X_06392_ net348 net617 net603 net441 VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__a22oi_2
X_08131_ _02099_ _02100_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__xnor2_1
X_05343_ _00593_ _00615_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__xnor2_1
X_08062_ _01870_ _02025_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07013_ _00872_ _00880_ _00881_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__nand3_1
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08964_ _03006_ _03007_ _03008_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__a21o_1
X_07915_ _01863_ _01864_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__nand2_1
XFILLER_102_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08895_ net616 net352 net601 net360 VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__a22o_1
XFILLER_29_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07846_ _01787_ _01788_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__and2b_1
X_07777_ _01536_ _01538_ _01712_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__and3_1
XFILLER_84_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06728_ net195 net180 VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__nand2_1
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09516_ _03487_ _03489_ _03610_ _03611_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_65_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09447_ _03525_ _03535_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06659_ _00405_ _00408_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_65_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09378_ net466 net245 VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__nand2_1
X_08329_ _02313_ _02314_ _02298_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_117_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10222_ _04297_ _04302_ _04377_ _04378_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__a211oi_1
XFILLER_58_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10153_ _04217_ _04219_ _04216_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__o21ba_1
XFILLER_87_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10084_ _04047_ _04227_ _04228_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__o21a_1
XFILLER_75_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap138 _01351_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_1
Xmax_cap149 _00228_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_1
XFILLER_112_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07700_ _01627_ _01629_ _01609_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__a21o_1
X_05961_ net481 net425 VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__and2_1
XFILLER_38_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08680_ _02696_ _02698_ net450 net264 VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__and4bb_1
X_05892_ net460 net195 _05021_ _05022_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__nand4_1
X_07631_ _01546_ _01553_ _01554_ VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_49_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07562_ net215 net575 VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__nand2_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06513_ _00334_ _00335_ _00336_ VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__nand3_1
X_09301_ _03197_ _03245_ _03376_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__o211a_1
X_07493_ _01401_ _01402_ _01240_ _01242_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_101_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06444_ _00261_ _00262_ VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__xnor2_1
X_09232_ _03300_ _03301_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__and2b_1
X_06375_ _00102_ _00104_ _00103_ VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__o21ba_1
XFILLER_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09163_ _03219_ _03226_ _03227_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__nand3_2
XFILLER_119_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08114_ _02070_ _02080_ _02081_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__and3_1
X_05326_ _00407_ _00418_ _00473_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__a21o_1
XFILLER_119_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09094_ _03150_ _03151_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__nand2_1
XFILLER_102_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08045_ _02004_ _02005_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__xor2_1
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09996_ _04129_ _04131_ _04133_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__o21a_2
X_08947_ _02693_ _02991_ _02990_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__a21o_1
XFILLER_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08878_ _02907_ _02914_ _02915_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__nand3_1
XFILLER_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07829_ _01767_ _01768_ _01764_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__a21o_1
XFILLER_72_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10205_ _04338_ _04358_ _04360_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__and3_1
XFILLER_94_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10136_ _04283_ _04284_ _04160_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__a21o_1
X_10067_ _04108_ _04209_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_89_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06160_ _05271_ _05287_ _05288_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__and3_1
X_06091_ _05119_ _05127_ _05126_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__a21bo_1
XFILLER_104_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09850_ _03966_ _03975_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08801_ _02830_ _02831_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__xnor2_1
X_06993_ net205 net625 net618 net209 VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__a22oi_1
X_09781_ _03898_ _03899_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__xor2_1
X_08732_ _02755_ _02756_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__and2b_1
X_05944_ _04999_ _05003_ _05073_ _05074_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__o211a_1
XFILLER_39_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08663_ _02680_ _02681_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__nand2_1
XFILLER_54_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05875_ _05005_ _05006_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__and2b_1
XFILLER_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07614_ _01535_ _01534_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__nand2b_1
X_08594_ _02601_ _02604_ _02605_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__nand3_1
X_07545_ _01458_ _01459_ _01450_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__a21o_1
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07476_ _01383_ _01384_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_62_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06427_ _00139_ _00246_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__and2_1
X_09215_ _03277_ _03282_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__xor2_1
X_06358_ _00174_ _00177_ VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__xnor2_1
X_09146_ net549 net248 VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__and2_1
XFILLER_108_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06289_ _00107_ _00108_ _00109_ VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__or3_1
X_05309_ net435 net479 net342 net487 VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__a22o_1
X_09077_ net399 net556 VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__nand2_1
X_08028_ _01985_ _01986_ _01982_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__a21o_1
XFILLER_116_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09979_ _04112_ _04113_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__xor2_1
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10119_ net567 net292 net560 net307 VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__a22o_1
XFILLER_95_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05660_ _03363_ _04125_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05591_ _03363_ _03374_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__or2_1
X_07330_ _01225_ _01226_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__nor2_1
XFILLER_16_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07261_ _00991_ _00993_ _01150_ _01151_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__o211ai_4
X_09000_ _03046_ _03048_ _03040_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__a21o_1
X_07192_ _01068_ _01074_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__xnor2_1
X_06212_ _05241_ _00033_ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__and2b_1
X_06143_ net492 net403 VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__nand2_1
XFILLER_117_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06074_ _05195_ _05203_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__nand2_1
XFILLER_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09902_ _04029_ _04030_ _03933_ _03935_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__o211a_1
Xfanout504 net506 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__buf_2
Xfanout515 net24 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout548 net549 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_2
XFILLER_86_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout537 net538 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__clkbuf_2
X_09833_ _03954_ _03955_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__or2_1
Xfanout526 net527 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_2
Xfanout559 net560 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__buf_2
XFILLER_86_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06976_ net423 net223 _00839_ _00840_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__o2bb2a_1
X_09764_ _03781_ _03880_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_29_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08715_ _02618_ _02620_ _02735_ _02736_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__o211ai_1
X_09695_ net613 net283 _03805_ _03806_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__a22o_1
X_05927_ _05055_ _05057_ _04998_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__a21oi_1
X_08646_ _02644_ _02645_ _02661_ _02662_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_1_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05858_ _04916_ _04990_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__xor2_1
XFILLER_26_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08577_ _02585_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05789_ net518 net420 net412 net606 VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__a22oi_1
X_07528_ _01405_ _01440_ _01441_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__nor3_1
X_07459_ _01364_ _01365_ _01208_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__o21ba_1
XFILLER_22_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10470_ _04646_ _04647_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__or2_1
XFILLER_41_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ _03013_ _03016_ net154 _03190_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__a211o_2
XFILLER_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10668_ net135 _02130_ _03255_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_97_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10599_ _04749_ _04750_ _04747_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__a21oi_1
Xoutput107 net107 VGND VGND VPWR VPWR C[48] sky130_fd_sc_hd__buf_2
XFILLER_114_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput118 net118 VGND VGND VPWR VPWR C[58] sky130_fd_sc_hd__buf_2
XFILLER_114_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06830_ _00534_ _00537_ _00681_ _00682_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__a211oi_2
XFILLER_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06761_ _00467_ net147 _00606_ _00607_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__o211ai_4
XFILLER_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06692_ _00530_ _00531_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__or2_1
X_08500_ _02500_ _02502_ _02491_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__a21o_1
X_05712_ _04656_ _04678_ _04645_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__a21oi_1
X_09480_ _03569_ _03571_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08431_ _02426_ _02427_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__and2b_1
X_05643_ _03297_ _03941_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_106_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08362_ _02133_ _02189_ _02188_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__a21oi_1
X_05574_ _03156_ _03167_ _03178_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_34_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07313_ _01206_ _01207_ _01051_ _01053_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__o211a_1
X_08293_ net402 net615 _02137_ _02136_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_34_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07244_ net302 net402 VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__nand2_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07175_ _00910_ _01057_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__nor2_1
X_06126_ net499 net397 net380 net521 VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__a22oi_1
X_06057_ _05183_ _05184_ _05185_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__a21o_1
Xfanout301 net302 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_2
Xfanout323 net47 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__clkbuf_2
Xfanout312 net313 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_4
Xfanout334 net335 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__clkbuf_2
Xfanout356 net357 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout345 net349 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout378 net382 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkbuf_4
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_2
X_09816_ _03935_ _03936_ _03831_ _03834_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__a211oi_1
Xfanout367 net368 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_2
XFILLER_100_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06959_ _00820_ _00821_ _00823_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__and3_1
XFILLER_74_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09747_ _03861_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09678_ _03785_ _03786_ net168 net258 VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__and4bb_1
XFILLER_36_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08629_ _02641_ _02642_ _02623_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10522_ _04644_ _04649_ _04701_ VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__a21oi_1
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10453_ _04554_ _04557_ _04555_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__o21ba_1
XFILLER_108_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10384_ _04489_ _04493_ _04553_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08980_ _03026_ _03027_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__xnor2_2
X_07931_ net519 net252 VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__nand2_1
X_07862_ _01805_ _01806_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__and2_1
XFILLER_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06813_ net448 net396 net379 net454 VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__a22o_1
XFILLER_68_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09601_ _03700_ _03702_ _03691_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__a21oi_1
XFILLER_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07793_ _01719_ _01729_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__and3_1
X_09532_ _03627_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_39_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06744_ _00586_ _00587_ _00585_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06675_ net521 net339 _00379_ _00378_ VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__a31o_1
XFILLER_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09463_ _03550_ _03552_ _03536_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__o21ai_1
XFILLER_36_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08414_ _02400_ _02407_ _02408_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__nand3_2
XFILLER_51_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09394_ _03475_ _03476_ _03465_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__a21oi_2
X_05626_ _03723_ _03744_ _03537_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__a21oi_1
X_08345_ net214 net526 VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__nand2_1
XFILLER_51_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05557_ _02971_ _02993_ _02479_ _02501_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__o211ai_2
XFILLER_32_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08276_ _02125_ _02127_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__nor2_1
X_05488_ _02184_ _02238_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_119_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07227_ net553 net370 VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__nand2_1
XFILLER_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07158_ _00999_ _01000_ _01036_ _01037_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06109_ _05081_ _05236_ _05238_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__and3_1
X_07089_ _00957_ _00963_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__nand2b_1
Xfanout164 net167 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_2
XFILLER_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout175 net8 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_2
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout197 net63 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10505_ _04138_ _04456_ _04683_ _04684_ _04685_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__a311o_1
XFILLER_109_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10436_ _04608_ _04609_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__nand2_1
XFILLER_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10367_ _04533_ _04534_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__xor2_1
XFILLER_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10298_ net322 net314 net508 net502 VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__and4_1
XFILLER_78_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_108_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06460_ _00269_ _00277_ VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_103_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05411_ _01398_ _01409_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_117_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08130_ net547 net316 VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__nand2_1
X_06391_ net441 net348 net617 net603 VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__and4_1
XFILLER_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05342_ _00287_ _00658_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__xnor2_1
X_08061_ _02022_ _02023_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__xnor2_1
X_07012_ _00877_ _00878_ _00879_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__a21o_1
XFILLER_103_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08963_ _03006_ _03007_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__nand3_1
X_07914_ _01689_ _01861_ _01862_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__or3_1
XFILLER_84_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08894_ net360 net616 net352 net601 VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nand4_1
XFILLER_96_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07845_ net407 net622 net615 net415 VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__a22o_1
XFILLER_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07776_ _01709_ _01710_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__xor2_1
XFILLER_71_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06727_ net205 net173 net165 net211 VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__a22oi_1
X_09515_ _03608_ _03609_ _03446_ _03491_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__a211oi_1
XFILLER_52_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09446_ _03533_ _03534_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__and2b_1
X_06658_ _00492_ _00494_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_65_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06589_ _00417_ _00419_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__xnor2_1
X_05609_ _03559_ _03570_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__nor2_1
X_09377_ _03457_ _03458_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__xnor2_1
X_08328_ _02298_ _02313_ _02314_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_117_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08259_ net450 net287 _02236_ _02237_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__nand4_2
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10221_ _04377_ _04378_ _04297_ _04302_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__o211a_1
XFILLER_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10152_ _04302_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__nand2_1
XFILLER_58_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10083_ net338 net513 net505 net353 VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__a22o_1
XFILLER_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap139 _01043_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_2
X_10419_ _04524_ _04528_ _04590_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__nor3_1
XFILLER_112_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05960_ net460 net190 net433 net473 VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__a22o_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05891_ net460 net195 _05021_ _05022_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__a22o_1
X_07630_ _01550_ _01552_ _01547_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__a21o_1
XFILLER_66_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07561_ _01468_ _01478_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__xor2_2
X_06512_ _00210_ _00212_ _00211_ VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__o21bai_1
X_09300_ _03329_ _03331_ _03373_ _03375_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__a22o_1
XFILLER_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07492_ _01240_ _01242_ _01401_ _01402_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__a211oi_2
X_06443_ net610 net339 VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__nand2_1
X_09231_ _03296_ _03298_ _03299_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__a21o_1
X_06374_ _00093_ _00095_ _00094_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__o21ba_1
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09162_ _03224_ _03225_ _03220_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__a21o_1
XFILLER_119_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08113_ _02078_ _02079_ _02071_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__a21o_1
X_05325_ _00407_ _00418_ _00473_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__nand3_1
X_09093_ _03147_ _03148_ _03149_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__nand3_1
XFILLER_119_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08044_ _02004_ _02005_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__nand2b_1
XFILLER_103_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09995_ _03948_ _04130_ _04132_ _04035_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__o22a_1
X_08946_ _02842_ _02689_ _02839_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__and3b_1
XFILLER_57_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08877_ _02911_ _02912_ _02913_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__a21o_1
X_07828_ _01764_ _01767_ _01768_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand3_1
XFILLER_84_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07759_ _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__inv_2
XFILLER_25_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09429_ _03393_ _03399_ _03271_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10204_ _04356_ _04357_ _04275_ _04278_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__a211o_1
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10135_ _04160_ _04283_ _04284_ VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__nand3_2
XFILLER_85_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10066_ _04207_ _04208_ _04162_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__o21ai_1
XFILLER_75_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06090_ _05217_ _05218_ _05210_ VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__a21o_1
XFILLER_112_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08800_ _02831_ _02830_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__and2b_1
XFILLER_112_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06992_ net209 net205 net625 net618 VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09780_ _03898_ _03899_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__or2_1
XFILLER_39_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08731_ _02751_ _02753_ _02754_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__a21o_1
X_05943_ net607 net398 net381 net628 VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__a22o_1
X_08662_ _02378_ _02524_ _02522_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07613_ _01371_ _01373_ _01370_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__o21ba_1
XFILLER_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05874_ net473 net190 net434 net481 VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__a22o_1
X_08593_ net369 net615 _02602_ _02603_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__nand4_1
XFILLER_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07544_ _01450_ _01458_ _01459_ VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__nand3_1
XFILLER_34_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07475_ net497 net288 VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__nand2_1
XFILLER_62_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06426_ _00137_ _00244_ VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__xnor2_1
XFILLER_22_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09214_ _03277_ _03282_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__nand2_1
X_06357_ _00175_ _00176_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__nor2_1
X_09145_ _03205_ _03206_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__xnor2_1
X_06288_ net348 net624 net617 net441 VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__a22oi_2
X_05308_ net435 net481 net342 net487 VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__nand4_1
XFILLER_30_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09076_ _03130_ _03131_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__and2b_1
XFILLER_100_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08027_ _01982_ _01985_ _01986_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__and3_1
XFILLER_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09978_ _04112_ _04113_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__or2_1
X_08929_ net143 _02970_ _02821_ _02823_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__o211ai_2
XFILLER_84_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10118_ net307 net566 net292 net560 VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_59_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10049_ _04188_ _04189_ _04182_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__a21o_1
XFILLER_63_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05590_ _03036_ _03352_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__nor2_1
XFILLER_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07260_ _01009_ _01011_ _01149_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__nand3_1
X_07191_ _01068_ _01072_ _01073_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__or3_1
X_06211_ _05248_ _00031_ VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__xnor2_1
X_06142_ _05186_ _05188_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__nand2_1
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06073_ _05196_ _05201_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__xnor2_1
X_09901_ _03933_ _03935_ _04029_ _04030_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__a211oi_2
XFILLER_113_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout505 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__buf_2
XFILLER_113_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_2
Xfanout538 net21 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__clkbuf_4
X_09832_ _03954_ _03955_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__nand2_1
Xfanout516 net518 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__buf_2
Xfanout549 net554 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__buf_2
XFILLER_98_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09763_ _03781_ _03880_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__nand2_1
X_06975_ _00839_ _00840_ net423 net223 VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__and4bb_1
X_08714_ _02618_ _02620_ _02735_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__o211a_1
X_09694_ net590 net305 net290 net597 VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__a22o_1
XFILLER_27_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05926_ _04998_ _05055_ _05057_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__and3_2
X_08645_ _02659_ _02660_ _02503_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_1_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05857_ _04987_ _04989_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__xnor2_1
XFILLER_27_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08576_ net298 net316 VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__nand2_1
XFILLER_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07527_ _01438_ _01439_ _01304_ _01307_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__a211oi_1
XFILLER_35_691 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05788_ net518 net606 net420 net412 VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__and4_1
XFILLER_50_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07458_ _01364_ _01365_ _01208_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__nor3b_1
X_07389_ _01288_ _01290_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__nor2_1
X_06409_ _00191_ _00193_ _00226_ _00227_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__or4_2
XFILLER_6_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09128_ _03184_ _03186_ _03171_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__o21a_1
X_09059_ _02972_ _02974_ _03111_ _03114_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_9_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10667_ _04852_ _04855_ _04848_ _04851_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_97_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10598_ _04782_ _04783_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__nor2_1
XFILLER_5_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput119 net119 VGND VGND VPWR VPWR C[59] sky130_fd_sc_hd__buf_2
Xoutput108 net108 VGND VGND VPWR VPWR C[49] sky130_fd_sc_hd__buf_2
XFILLER_99_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput90 net90 VGND VGND VPWR VPWR C[32] sky130_fd_sc_hd__buf_2
XFILLER_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06760_ _00602_ _00603_ _00566_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__o21ai_2
XFILLER_83_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06691_ _00528_ _00529_ _00520_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__a21oi_1
X_05711_ _04667_ _04678_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__xnor2_1
XFILLER_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08430_ net220 net331 net324 net298 VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a22o_1
X_05642_ _03897_ _03908_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08361_ _02296_ _02351_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__xor2_1
X_05573_ _03156_ _03167_ _03178_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__nand3_1
XFILLER_32_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07312_ _01051_ _01053_ _01206_ _01207_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__a211oi_2
X_08292_ _02115_ _02118_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07243_ _01129_ _01130_ _00969_ _00972_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__o211a_1
X_07174_ _01055_ _01056_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__or2_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06125_ net499 net521 net396 net379 VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__and4_1
XFILLER_105_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06056_ _05183_ _05184_ _05185_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__nand3_1
XFILLER_101_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_2
Xfanout313 net319 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_4
Xfanout324 net47 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_4
Xfanout335 net46 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_4
Xfanout357 net43 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09815_ _03937_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__inv_2
Xfanout346 net349 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__buf_2
XFILLER_101_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout379 net381 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout368 net373 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkbuf_2
X_06958_ _00661_ _00670_ _00668_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__a21bo_1
XFILLER_86_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09746_ net581 net313 VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__nand2_1
X_05909_ _05037_ _05038_ _05039_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__a21o_1
X_09677_ net168 net258 _03785_ _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__o2bb2a_1
X_06889_ _00744_ _00745_ _00602_ _00605_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__a211oi_1
X_08628_ _02623_ _02641_ _02642_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__nand3_2
XFILLER_15_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08559_ _02564_ _02565_ _02558_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_81_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10521_ _04644_ _04649_ _04701_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__and3_1
XFILLER_10_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10452_ _04585_ _04627_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__xnor2_1
X_10383_ _04489_ _04493_ _04553_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__and3_1
XFILLER_117_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07930_ _01877_ _01879_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__xnor2_1
XFILLER_102_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07861_ _01803_ _01804_ _01784_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__a21o_1
X_07792_ _01727_ _01728_ _01720_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__a21o_1
XFILLER_95_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06812_ net454 net448 net396 net379 VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__nand4_1
XFILLER_56_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09600_ _03691_ _03700_ _03702_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_108_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06743_ _00585_ _00586_ _00587_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__or3_1
X_09531_ net584 net320 net576 net328 VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_39_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06674_ _00510_ _00511_ VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__xnor2_1
X_09462_ _03536_ _03550_ _03552_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__or3_2
X_08413_ _02405_ _02406_ _02401_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__a21o_1
XFILLER_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09393_ _03465_ _03475_ _03476_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__nand3_1
X_05625_ _03537_ _03723_ _03744_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__and3_1
X_08344_ _02331_ _02332_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__and2_1
X_05556_ _02479_ _02501_ _02971_ _02993_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__a211o_1
XFILLER_51_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08275_ _02213_ _02256_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__xor2_1
X_05487_ _02184_ _02238_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_119_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07226_ _00979_ _00981_ _00980_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__o21ba_1
X_07157_ _00999_ _01000_ _01036_ _01037_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__or4bb_2
X_06108_ _05234_ _05235_ _05140_ _05142_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__o211ai_1
XFILLER_105_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07088_ _00958_ _00961_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__xnor2_1
X_06039_ _05100_ _05102_ _05168_ VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__and3_1
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_101_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout187 net188 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_2
XFILLER_59_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_2
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
X_09729_ _03840_ _03841_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__xnor2_1
XFILLER_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10504_ _04582_ _04682_ _04683_ _04455_ VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_109_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10435_ _04608_ _04609_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_94_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10366_ _04533_ _04534_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__and2b_1
X_10297_ net314 net502 VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__nand2_1
XFILLER_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05410_ net516 net217 VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__nand2_1
XFILLER_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06390_ net254 net624 VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__nand2_1
XFILLER_119_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05341_ _00636_ _00647_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__nor2_1
XFILLER_119_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08060_ _02022_ _02023_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__or2_1
X_07011_ _00877_ _00878_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__nand3_1
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08962_ _02909_ _02910_ _02908_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__a21bo_1
X_07913_ _01861_ _01862_ _01689_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__o21ai_1
X_08893_ _02931_ _02932_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__xnor2_1
XFILLER_110_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07844_ net415 net407 net621 net615 VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__and4_1
XFILLER_110_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07775_ net608 net252 _01709_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__nand3_1
XFILLER_84_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06726_ net211 net205 net173 net165 VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__and4_1
X_09514_ _03446_ _03491_ _03608_ _03609_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__o211a_1
X_06657_ _00255_ _00369_ _00493_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__a21oi_1
X_09445_ _03530_ _03531_ _03532_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_65_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05608_ net229 net459 net452 net235 VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__a22oi_1
X_06588_ net469 net426 VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__nand2_1
X_09376_ _03457_ _03458_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__or2_1
X_08327_ _02311_ _02312_ _02303_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__a21o_1
X_05539_ _02796_ _02807_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__xnor2_1
X_08258_ net450 net287 _02236_ _02237_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__a22o_1
X_07209_ net485 net477 net333 net326 VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__and4_1
XFILLER_106_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08189_ _02157_ _02161_ _02163_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__and3_1
X_10220_ _04374_ _04376_ _04258_ _04261_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__o211a_1
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10151_ _04297_ _04298_ _04301_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__a21o_1
XFILLER_58_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10082_ net338 net505 VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__nand2_1
XFILLER_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap129 _00907_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XFILLER_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10418_ _04524_ _04528_ _04590_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__o21a_1
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10349_ _04444_ _04447_ _04515_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__a21o_1
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05890_ net204 net453 net447 net213 VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__a22o_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07560_ _01476_ _01477_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__and2b_1
XFILLER_65_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06511_ _00332_ _00333_ _00330_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__o21ai_1
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07491_ _01399_ _01400_ _01283_ _01285_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__a211oi_1
X_09230_ _03296_ _03298_ _03299_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__and3_1
XFILLER_34_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06442_ _00259_ _00260_ VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__and2b_1
XFILLER_61_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06373_ _00189_ _00190_ _00082_ _00084_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__a211oi_2
X_09161_ _03220_ _03224_ _03225_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__nand3_2
XFILLER_119_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08112_ _02071_ _02078_ _02079_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__nand3_1
XFILLER_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05324_ _00451_ _00462_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__xor2_1
X_09092_ _03147_ _03148_ _03149_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__a21o_1
X_08043_ _01823_ _01832_ _01831_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09994_ _03946_ _04036_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__nor2_1
XFILLER_103_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08945_ _02688_ _02839_ _02842_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__a21oi_1
X_08876_ _02911_ _02912_ _02913_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__nand3_1
X_07827_ net222 net369 _01765_ _01766_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__nand4_1
X_07758_ _01367_ _01524_ _01525_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__a21o_1
XFILLER_56_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06709_ net191 net432 net301 net223 VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__and4_1
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07689_ net428 net600 net593 net185 VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__a22oi_2
XFILLER_52_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09428_ _03513_ _03514_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09359_ _03317_ _03321_ _03438_ _03440_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__a211oi_2
XFILLER_100_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10203_ _04358_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__inv_2
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10134_ _04281_ _04282_ _04262_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__a21o_1
XFILLER_48_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10065_ _04162_ _04207_ _04208_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_89_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06991_ net194 net165 VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__nand2_1
X_08730_ _02751_ _02753_ _02754_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__and3_1
X_05942_ net606 net628 net398 net381 VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__nand4_1
X_08661_ _02537_ _02679_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__xnor2_1
X_05873_ net481 net473 net190 net434 VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__and4_1
X_07612_ _01532_ _01533_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__xnor2_1
XFILLER_93_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08592_ net369 net615 _02602_ _02603_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__a22o_1
XFILLER_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07543_ _01455_ _01456_ _01457_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__a21o_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07474_ _01381_ _01382_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_62_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06425_ _00137_ _00244_ VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__and2b_1
XFILLER_10_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09213_ _03280_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__xnor2_1
X_09144_ _03206_ _03205_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__and2b_1
X_06356_ net454 net419 net411 net461 VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__a22oi_1
XFILLER_107_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06287_ net441 net348 net624 net617 VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__and4_1
X_05307_ net234 net228 net605 net629 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__and4_1
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09075_ net405 net540 net532 net413 VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__a22o_1
X_08026_ net194 net575 _01983_ _01984_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__nand4_1
XFILLER_30_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09977_ _04020_ _04022_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__nor2_1
XFILLER_39_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08928_ _02821_ _02823_ net144 _02970_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__a211o_2
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08859_ _02648_ _02895_ _02893_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__o21a_1
XFILLER_44_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10117_ net315 net560 _04141_ _04140_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__a31o_1
XFILLER_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10048_ _04182_ _04188_ _04189_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_59_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06210_ _05248_ _00031_ VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__and2b_1
XFILLER_31_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07190_ _01072_ _01073_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nor2_1
X_06141_ _05250_ _05269_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__xnor2_1
XFILLER_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06072_ _05196_ _05201_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_20_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09900_ _04026_ _04028_ _03924_ _03926_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__o211a_1
XFILLER_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout506 net25 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout539 net546 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__buf_2
Xfanout528 net530 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__clkbuf_2
Xfanout517 net518 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__buf_2
X_09831_ net368 net529 _03848_ _03847_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__a31o_1
XFILLER_113_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06974_ net429 net181 net173 net187 VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__a22oi_1
X_09762_ _03878_ _03879_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__nand2b_1
X_08713_ _02731_ _02733_ _02712_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__a21o_1
X_05925_ _05052_ _05054_ _04972_ _04975_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__o211ai_1
X_09693_ net597 net590 net305 net290 VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__nand4_2
XFILLER_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08644_ _02503_ _02659_ _02660_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand3b_2
X_05856_ _04911_ _04914_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__nand2_1
XFILLER_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08575_ _02583_ _02584_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_1_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05787_ _04816_ _04837_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__nand2_1
X_07526_ _01304_ _01307_ _01438_ _01439_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__o211a_1
XFILLER_81_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07457_ _01362_ _01363_ _01204_ _01206_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__a211oi_1
X_07388_ net409 net182 net174 net417 VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__a22oi_1
X_06408_ _00191_ _00193_ _00226_ _00227_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_20_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06339_ _00157_ _00158_ VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__xnor2_1
X_09127_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__inv_2
X_09058_ _03064_ _03066_ _03109_ _03110_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__a2bb2oi_2
X_08009_ _01963_ _01964_ _01965_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_9_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10666_ _04853_ _04855_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_97_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10597_ _04780_ _04781_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__and2_1
XFILLER_5_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput109 net109 VGND VGND VPWR VPWR C[4] sky130_fd_sc_hd__buf_2
XFILLER_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput91 net91 VGND VGND VPWR VPWR C[33] sky130_fd_sc_hd__buf_2
XFILLER_110_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput80 net80 VGND VGND VPWR VPWR C[23] sky130_fd_sc_hd__buf_2
XFILLER_110_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06690_ _00520_ _00528_ _00529_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__and3_1
X_05710_ _03962_ _03973_ _03951_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__a21o_1
XFILLER_91_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05641_ _02610_ _03897_ _03167_ _03156_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__and4bb_1
XFILLER_24_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08360_ _02347_ _02349_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__xor2_1
XFILLER_17_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07311_ _01204_ _01205_ _00937_ _00939_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__o211a_1
X_05572_ net141 _02621_ _02599_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__a21oi_1
X_08291_ _02264_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_34_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07242_ _00969_ _00972_ _01129_ _01130_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__a211oi_2
XFILLER_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07173_ _01053_ _01054_ _00905_ _00907_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__a211oi_1
X_06124_ _05175_ _05177_ _05176_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__o21ba_1
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06055_ _05091_ _05092_ _05090_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__a21bo_1
XFILLER_99_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout303 net5 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_2
Xfanout314 net319 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_4
Xfanout325 net47 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_70_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout347 net348 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09814_ _03831_ _03834_ _03935_ _03936_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__o211a_1
Xfanout336 net338 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout369 net370 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__buf_2
Xfanout358 net360 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__buf_2
XFILLER_100_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06957_ _00818_ _00819_ _00812_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__a21o_1
X_09745_ _03859_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__and2b_1
X_06888_ _00602_ _00605_ _00744_ _00745_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__o211a_1
X_05908_ _05037_ _05038_ _05039_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__nand3_1
X_09676_ net619 net274 net265 net159 VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__a22oi_1
XFILLER_27_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08627_ _02639_ _02640_ _02624_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__a21o_1
X_05839_ _04892_ _04895_ _04969_ _04971_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__a211o_1
XFILLER_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08558_ _02558_ _02564_ _02565_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__nand3_2
X_07509_ _01411_ _01421_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_81_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08489_ _02324_ _02327_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__nand2_1
XFILLER_23_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10520_ _04699_ _04700_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__nand2_1
XFILLER_22_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10451_ _04585_ _04627_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__nand2_1
XFILLER_108_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10382_ _04551_ _04552_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__nand2_1
XFILLER_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10649_ _04838_ _04836_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_11_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07860_ _01784_ _01803_ _01804_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__nand3_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07791_ _01720_ _01727_ _01728_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__nand3_1
XFILLER_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06811_ net448 net403 _00546_ _00545_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_108_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06742_ net347 net588 net580 net440 VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__a22oi_2
X_09530_ net328 net584 net320 net576 VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_39_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09461_ _03546_ _03547_ _03549_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06673_ net499 net339 VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__nand2_1
X_08412_ _02401_ _02405_ _02406_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_19_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09392_ _03465_ _03475_ _03476_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__and3_1
X_05624_ _03690_ _03701_ _03712_ VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__a21o_1
X_08343_ _02329_ _02330_ _02321_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__a21o_1
X_05555_ _02949_ _02960_ _02763_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__a21oi_1
X_08274_ _02214_ _02254_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__xor2_1
XFILLER_20_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07225_ net449 net370 _00961_ _00959_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__a31o_1
X_05486_ _02195_ _02227_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_119_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07156_ _01033_ _01035_ _00885_ _00889_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__o211ai_1
XFILLER_3_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07087_ _00959_ _00960_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__nor2_1
X_06107_ _05236_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__inv_2
X_06038_ _05166_ _05167_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__xnor2_1
XFILLER_59_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_2
XFILLER_59_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout177 net179 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_2
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_2
Xfanout188 net64 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_2
XFILLER_101_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07989_ _01942_ _01943_ _01936_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a21o_1
XFILLER_86_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09728_ _03838_ _03839_ _03841_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__and3_1
XFILLER_27_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09659_ _03764_ _03765_ _03767_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__a21o_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10503_ _04578_ _04633_ _04632_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__a21oi_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10434_ net563 net249 VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__and2_1
XFILLER_109_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10365_ _04464_ _04469_ _04473_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__a21bo_1
XFILLER_112_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10296_ net314 net508 net502 net322 VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__a22o_1
XFILLER_93_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05340_ _00484_ _00495_ _00626_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07010_ _00725_ _00727_ _00726_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_114_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08961_ _03002_ _03004_ _03005_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__nand3_1
X_07912_ _01859_ _01860_ _01542_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08892_ net178 net313 VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__nand2_1
X_07843_ net401 net161 VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__nand2_1
XFILLER_84_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07774_ net608 net252 VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__nand2_1
XFILLER_84_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06725_ _00444_ _00446_ _00445_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__o21bai_1
X_09513_ _03563_ _03564_ _03606_ _03607_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__a22o_1
XFILLER_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06656_ _00245_ _00247_ _00368_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__o21a_1
X_09444_ _03530_ _03531_ _03532_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05607_ net235 net229 net459 net452 VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__and4_1
X_06587_ _00415_ _00416_ VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__and2b_1
XFILLER_33_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09375_ _03339_ _03340_ _03338_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__a21oi_1
X_08326_ _02303_ _02311_ _02312_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__nand3_1
XFILLER_20_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05538_ net479 net217 VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__nand2_1
X_08257_ net547 net308 net294 net443 VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_49_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05469_ _01529_ _02021_ _02032_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand3_1
XFILLER_116_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07208_ _00934_ _01090_ _01091_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__or3_1
X_08188_ _02159_ _02160_ _02158_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__a21bo_1
X_07139_ net255 net574 VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__nand2_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10150_ _04297_ _04298_ _04301_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__nand3_1
X_10081_ _04225_ _04226_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__xnor2_1
XFILLER_101_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_67_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10417_ _04588_ _04589_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__xnor2_1
X_10348_ _04444_ _04447_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__nand2_1
XFILLER_112_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10279_ _04439_ _04441_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__and2_1
XFILLER_38_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07490_ _01283_ _01285_ _01399_ _01400_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__o211a_1
XFILLER_81_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06510_ _00330_ _00332_ _00333_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__or3_1
XFILLER_46_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06441_ net498 net364 net356 net520 VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06372_ _00082_ _00084_ _00189_ _00190_ VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__o211ai_2
X_09160_ net219 net282 _03221_ _03223_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__nand4_2
XFILLER_119_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08111_ _02076_ _02077_ _02072_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__a21o_1
X_05323_ net217 net629 VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__nand2_1
X_09091_ _03009_ _03011_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__nand2_1
XFILLER_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08042_ _01996_ _02003_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_116_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09993_ _03949_ _04130_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__or2_1
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08944_ _02985_ _02986_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__xnor2_1
XFILLER_88_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08875_ _02803_ _02804_ _02802_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__a21bo_1
XFILLER_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07826_ net222 net369 _01765_ _01766_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__a22o_1
X_07757_ _01521_ _01690_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__xor2_2
XFILLER_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06708_ _00547_ _00548_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07688_ net185 net428 net600 net593 VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__and4_1
XFILLER_71_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06639_ _00408_ _00409_ _00472_ _00474_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__and4bb_1
X_09427_ net400 net525 VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__nand2_1
XFILLER_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09358_ _03436_ _03437_ _03285_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__a21oi_1
X_08309_ _02292_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__nand2_1
XFILLER_60_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09289_ _03231_ _03234_ _03362_ _03364_ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_78_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10202_ _04275_ _04278_ _04356_ _04357_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__o211ai_2
XFILLER_79_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10133_ _04262_ _04281_ _04282_ VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__nand3_2
XFILLER_0_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10064_ _04205_ _04206_ _04163_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_89_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_84_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06990_ _00720_ _00722_ _00719_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__o21ba_1
XFILLER_78_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05941_ net606 net628 net398 net381 VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__and4_1
X_08660_ _02674_ _02675_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__xnor2_1
X_05872_ _05002_ _05003_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__nor2_1
XFILLER_39_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07611_ net608 net264 VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_93_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08591_ net377 net600 net593 net393 VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__a22o_1
XFILLER_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07542_ _01455_ _01456_ _01457_ VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__nand3_1
X_07473_ net483 net310 net296 net490 VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_62_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06424_ _00240_ _00241_ VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_62_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09212_ net399 net540 VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__nand2_1
X_06355_ net461 net454 net419 net411 VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__and4_1
X_09143_ _03067_ _03071_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__nor2_1
X_06286_ net254 net164 VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__nand2_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09074_ net413 net405 net540 net532 VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__and4_1
X_08025_ net194 net571 _01983_ _01984_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__a22o_1
XFILLER_89_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09976_ _04110_ _04111_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__nand2_1
X_08927_ _02925_ _02926_ _02966_ _02967_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__o22a_1
XFILLER_29_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08858_ net197 net503 VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__nand2_1
X_07809_ _01746_ _01748_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__and2b_1
XFILLER_55_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08789_ _02815_ _02816_ _02793_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10116_ _04184_ _04187_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__nand2_1
XFILLER_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10047_ _04186_ _04187_ _04183_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__a21o_1
XFILLER_48_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06140_ _05251_ _05267_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__xnor2_1
X_06071_ _05197_ _05200_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__xnor2_1
XFILLER_113_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout518 net522 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_2
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_2
X_09830_ _03743_ _03953_ _03952_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__o21a_1
Xfanout529 net530 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__buf_2
XFILLER_112_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06973_ net187 net429 net181 net173 VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__and4_1
X_09761_ _03757_ _03775_ _03877_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__or3b_1
X_08712_ _02712_ _02731_ _02733_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__nand3_1
X_05924_ _05055_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__inv_2
X_09692_ net590 net313 _03628_ _03627_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__a31o_1
X_08643_ net214 net506 _02657_ _02658_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__a22o_1
X_05855_ _04911_ _04987_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__nor2_1
X_08574_ net178 net331 net324 net220 VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05786_ _04917_ _04918_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__and2_1
XFILLER_42_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07525_ _01435_ _01437_ _01422_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07456_ _01204_ _01206_ _01362_ _01363_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__o211a_1
XFILLER_10_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07387_ net417 net409 net182 net174 VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__and4_1
X_06407_ _00223_ _00225_ _00118_ _00121_ VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_20_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06338_ net499 net372 VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__nand2_1
X_09126_ _03171_ _03184_ _03186_ VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__nor3_1
XFILLER_108_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06269_ _00086_ _00087_ _05283_ _05285_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__a211oi_2
X_09057_ _03064_ _03066_ _03109_ _03110_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__or4bb_1
X_08008_ _01963_ _01964_ _01965_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__a21o_1
XFILLER_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09959_ _04082_ _04091_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__and3_2
XFILLER_106_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10665_ _04823_ _04844_ _04854_ _04843_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__a211o_1
XFILLER_41_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10596_ _04780_ _04781_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__nor2_1
XFILLER_114_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net70 VGND VGND VPWR VPWR C[14] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR C[34] sky130_fd_sc_hd__buf_2
XFILLER_110_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput81 net81 VGND VGND VPWR VPWR C[24] sky130_fd_sc_hd__buf_2
XFILLER_110_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05640_ _03156_ _03897_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__nor2_1
XFILLER_91_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05571_ _03134_ _03145_ _02577_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__o21ai_2
XFILLER_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07310_ _00937_ _00939_ _01204_ _01205_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__a211oi_2
XFILLER_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08290_ _02272_ _02273_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__and2b_1
XFILLER_31_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07241_ _01127_ _01128_ _00996_ _00999_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__a211oi_1
XFILLER_31_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07172_ _00905_ _00907_ _01053_ _01054_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__o211a_1
XFILLER_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06123_ _05158_ _05160_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__or2_1
X_06054_ _05181_ _05182_ _05180_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__a21bo_1
Xfanout304 net305 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout348 net349 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_4
Xfanout337 net338 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_2
Xfanout315 net319 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_6_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09813_ _03932_ _03934_ _03825_ _03827_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__o211ai_1
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout359 net360 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06956_ _00812_ _00818_ _00819_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__nand3_1
X_09744_ net323 net573 net566 net330 VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__a22o_1
XFILLER_100_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06887_ _00705_ _00706_ _00742_ _00743_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__a2bb2o_1
X_09675_ net159 net619 net274 net265 VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__and4_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05907_ _04956_ _04958_ _04957_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__o21bai_1
X_08626_ _02624_ _02639_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__nand3_2
XFILLER_54_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05838_ _04967_ _04968_ _04950_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_53_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08557_ _02562_ _02563_ _02559_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__a21o_1
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05769_ _04899_ _04900_ _04901_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__a21oi_1
X_07508_ _01418_ _01419_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_81_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08488_ _02488_ _02489_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__nor2_1
XFILLER_23_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07439_ _01341_ _01343_ _01184_ _01187_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__o211ai_1
X_10450_ _04625_ _04626_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__xor2_1
X_09109_ _03164_ _03165_ _03166_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__a21o_1
XFILLER_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10381_ _04549_ _04550_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__nand2_1
XFILLER_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10648_ _04804_ _04806_ _04809_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__o21ba_1
XFILLER_115_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10579_ _04762_ _04764_ VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__and2b_1
XFILLER_114_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07790_ _01724_ _01726_ _01721_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__a21o_1
X_06810_ _00522_ _00525_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__nand2_1
XFILLER_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06741_ net440 net347 net587 net580 VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__and4_1
X_09460_ _03546_ _03547_ _03549_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__nand3_1
XFILLER_36_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06672_ _00508_ _00509_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__and2b_1
X_08411_ net443 net286 _02403_ _02404_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__nand4_2
XFILLER_64_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09391_ _03473_ _03474_ _03466_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_19_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05623_ _03723_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__inv_2
X_08342_ _02321_ _02329_ _02330_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand3_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05554_ _02763_ _02949_ _02960_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__nand3_1
X_08273_ _02254_ _02214_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__nand2b_1
X_05485_ _02206_ _02216_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__nor2_1
X_07224_ _01109_ _01110_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_119_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07155_ _00885_ _00889_ _01033_ _01035_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__a211o_1
XFILLER_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07086_ net470 net396 net379 net553 VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__a22oi_1
X_06106_ _05140_ _05142_ _05234_ _05235_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__a211o_1
X_06037_ _05072_ _05075_ VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__nor2_1
XFILLER_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07988_ _01936_ _01942_ _01943_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__nand3_1
Xfanout167 net9 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net192 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
XFILLER_47_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06939_ net477 net462 net364 net356 VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _03841_ _03840_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__nand2b_1
XFILLER_55_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09658_ net336 net562 VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__and2_1
XFILLER_70_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08609_ _02480_ _02482_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__nand2_1
XFILLER_63_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09589_ _03585_ _03588_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__nand2_1
XFILLER_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10502_ _04583_ _04682_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__nor2_1
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10433_ _04605_ _04606_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_94_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10364_ _04530_ _04531_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__xor2_1
XFILLER_88_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10295_ _04452_ _04457_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__xnor2_1
XFILLER_104_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08960_ _03002_ _03004_ _03005_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__a21o_1
X_07911_ _01542_ _01859_ _01860_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__and3_1
X_08891_ _02929_ _02930_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__and2b_1
X_07842_ _01632_ _01641_ _01640_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__a21o_1
XFILLER_68_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07773_ _01706_ _01707_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__xnor2_1
X_09512_ _03563_ _03564_ _03606_ _03607_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__nand4_2
X_06724_ _00434_ _00437_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__nand2_1
XFILLER_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06655_ _00367_ _00490_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__xnor2_2
XFILLER_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09443_ _03411_ _03412_ _03410_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_65_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05606_ net217 net471 VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__nand2_1
X_09374_ _03455_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__xnor2_1
X_06586_ net432 net389 net301 net191 VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__a22o_1
X_08325_ _02308_ _02309_ _02310_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__a21o_1
XFILLER_52_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05537_ _02774_ _02785_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_104_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08256_ net547 net443 net308 net294 VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__nand4_2
X_05468_ _01529_ _02021_ _02032_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__and3_1
X_07207_ _01090_ _01091_ _00934_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__o21ai_1
X_08187_ _02158_ _02159_ _02160_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__nand3b_1
X_07138_ _01013_ _01016_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__xnor2_1
X_05399_ net435 net342 net471 net459 VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__and4_1
X_07069_ net485 net491 net333 net326 VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__and4_1
X_10080_ _04128_ _04138_ _04126_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__a21oi_1
XFILLER_114_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10416_ net284 net524 VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__nand2_1
XFILLER_99_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10347_ _04513_ _04514_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10278_ _04363_ _04366_ _04438_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__or3_1
XFILLER_93_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap1 _00749_ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06440_ net498 net520 net364 net356 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__and4_1
XFILLER_61_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06371_ _00082_ _00084_ _00189_ _00190_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__o211a_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08110_ _02072_ _02076_ _02077_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nand3_2
X_05322_ _00429_ _00440_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__or2_1
X_09090_ _02648_ _02895_ _03144_ _03146_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_119_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08041_ _02000_ _02001_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_116_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09992_ _03947_ _04037_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__nand2_1
X_08943_ _02985_ _02986_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__nand2_1
XFILLER_84_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08874_ _02908_ _02909_ _02910_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__nand3_1
X_07825_ net393 net174 net377 net178 VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__a22o_1
XFILLER_84_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07756_ _01521_ _01690_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__and2b_1
XFILLER_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06707_ net448 net403 VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__nand2_1
XFILLER_25_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07687_ net422 net615 VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__nand2_1
X_09426_ _03511_ _03512_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__and2b_1
X_06638_ _00470_ _00471_ _00348_ _00350_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__a211o_1
XFILLER_25_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06569_ _00390_ _00395_ VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__xnor2_1
X_09357_ _03285_ _03436_ _03437_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__and3_2
XFILLER_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08308_ _02290_ _02291_ _02150_ _02153_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__a211o_1
X_09288_ _03360_ _03361_ _03226_ _03228_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__o211a_1
X_08239_ _02215_ _02217_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_78_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10201_ _04354_ _04355_ _04271_ _04273_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__o211ai_2
X_10132_ _04279_ _04280_ _04193_ _04195_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__a211o_1
XFILLER_87_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10063_ _04163_ _04205_ _04206_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__and3_1
XFILLER_75_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05940_ _04985_ _05067_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__nand2b_1
XFILLER_78_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05871_ net606 net404 _05001_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__and3_1
XFILLER_38_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07610_ _01530_ _01531_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__nor2_1
XFILLER_93_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08590_ net393 net377 net600 net593 VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__nand4_1
XFILLER_54_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07541_ net422 net166 _01295_ _01294_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__a31o_1
X_07472_ net483 net490 net310 net296 VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_62_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06423_ _00242_ VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_62_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09211_ _03278_ _03279_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__and2b_1
X_06354_ net476 net403 VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__nand2_1
X_09142_ _03203_ _03204_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__nor2_1
X_06285_ _00102_ _00105_ VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__xnor2_1
X_09073_ _03078_ _03079_ _03083_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__o21ai_1
X_08024_ net199 net568 net558 net208 VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__a22o_1
XFILLER_89_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09975_ _04108_ _04109_ _04024_ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08926_ _02925_ _02926_ _02966_ _02967_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__or4_1
X_08857_ net197 net510 net503 net198 VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__a22o_1
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07808_ net548 net332 net325 net444 VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__a22o_1
XFILLER_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08788_ _02793_ _02815_ _02816_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__nand3_1
XFILLER_55_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07739_ _01503_ _01505_ _01670_ _01672_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__o211ai_4
XFILLER_40_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09409_ _03491_ _03492_ _03329_ _03376_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_23_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10115_ _04144_ _04152_ _04151_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__a21o_1
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10046_ _04183_ _04186_ _04187_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__nand3_2
XFILLER_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06070_ _05198_ _05199_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__nor2_1
XANTENNA_1 _03265_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout519 net522 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__buf_2
XFILLER_112_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout508 net24 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_2
X_06972_ _00834_ _00837_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__xnor2_1
X_09760_ _03757_ _03775_ _03877_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__o21ba_1
XFILLER_100_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08711_ _02712_ _02731_ _02733_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__and3_1
X_09691_ _03694_ _03697_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__nand2_1
X_05923_ _04972_ _04975_ _05052_ _05054_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__a211o_1
XFILLER_82_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08642_ net214 net506 _02657_ _02658_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__nand4_4
XFILLER_27_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05854_ _04985_ _04986_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__nand2_1
X_08573_ net220 net178 net331 net324 VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__and4_1
X_05785_ _04730_ _04856_ _04863_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__or3_1
X_07524_ _01422_ _01435_ _01437_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__or3_1
X_07455_ _01359_ _01361_ _01218_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06406_ _00118_ _00121_ _00223_ _00225_ VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__a211oi_4
XFILLER_50_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07386_ net225 net402 VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06337_ _00155_ _00156_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__nor2_1
X_09125_ _03181_ _03182_ _03183_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__a21oi_1
XFILLER_108_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06268_ _05283_ _05285_ _00086_ _00087_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__o211ai_2
X_09056_ _03064_ _03066_ _03109_ _03110_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__and4bb_1
X_08007_ net422 net594 VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__and2_1
XFILLER_89_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06199_ _05289_ _05291_ _00017_ _00018_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__o22ai_1
XFILLER_1_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09958_ _04089_ _04090_ _04083_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__a21o_1
X_08909_ net367 net594 _02947_ _02948_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__nand4_1
XFILLER_106_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09889_ _03998_ _04015_ _04017_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__nand3_1
XFILLER_45_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10664_ _04842_ _04815_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__and2b_1
XFILLER_40_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10595_ net531 net242 VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_97_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput93 net93 VGND VGND VPWR VPWR C[35] sky130_fd_sc_hd__buf_2
XFILLER_110_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput82 net82 VGND VGND VPWR VPWR C[25] sky130_fd_sc_hd__buf_2
XFILLER_68_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput71 net71 VGND VGND VPWR VPWR C[15] sky130_fd_sc_hd__buf_2
XFILLER_110_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10029_ _04064_ _04067_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__nor2_1
XFILLER_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05570_ _02577_ _03134_ _03145_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_106_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07240_ _00996_ _00999_ _01127_ _01128_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__o211a_1
XFILLER_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07171_ _01051_ _01052_ _00791_ _00793_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__a211o_1
X_06122_ _05174_ _05188_ _05189_ _05192_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__a31o_1
XFILLER_8_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06053_ _05180_ _05181_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__nand3b_1
Xfanout305 net49 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_4
Xfanout316 net318 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_4
Xfanout327 net47 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_1
XFILLER_99_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09812_ _03825_ _03827_ _03932_ _03934_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__a211o_1
Xfanout338 net341 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__buf_2
Xfanout349 net44 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__buf_2
X_06955_ _00816_ _00817_ _00813_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__a21o_1
XFILLER_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09743_ net329 net321 net573 net566 VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__and4_1
X_06886_ _00705_ _00706_ _00742_ _00743_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__or4bb_2
XFILLER_54_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05906_ _05035_ _05036_ _05034_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__o21ai_1
X_09674_ _03665_ _03782_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08625_ _02637_ _02638_ _02629_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__a21o_1
XFILLER_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05837_ _04950_ _04967_ _04968_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__nand3_1
X_08556_ _02559_ _02562_ _02563_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_53_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07507_ _01415_ _01416_ _01417_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__a21o_1
X_05768_ _04899_ _04900_ _04901_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__and3_1
XFILLER_42_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08487_ net227 net214 net512 net503 VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__and4_1
XFILLER_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05699_ _03395_ _04548_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__and2_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07438_ _01184_ _01187_ _01341_ _01343_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__a211o_1
XFILLER_23_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07369_ net302 net394 net378 net388 VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__a22oi_1
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09108_ _03164_ _03165_ _03166_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__and3_1
X_10380_ _04549_ _04550_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__or2_1
X_09039_ _03087_ _03090_ _03092_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__nand3_2
XFILLER_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10647_ _04834_ _04835_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__nor2_1
XFILLER_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10578_ _04760_ _04761_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__or2_1
XFILLER_56_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06740_ net255 net595 VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nand2_1
XFILLER_36_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06671_ net485 net365 net357 net491 VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__a22o_1
XFILLER_76_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08410_ net443 net286 _02403_ _02404_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__a22o_1
XFILLER_64_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05622_ _03690_ _03701_ _03712_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__nand3_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09390_ _03466_ _03473_ _03474_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_19_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08341_ _02327_ _02328_ _02322_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__a21o_1
X_05553_ _02763_ _02949_ _02960_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__and3_1
X_08272_ _02232_ _02253_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05484_ net494 net206 net201 net517 VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__a22oi_1
X_07223_ _01099_ _01108_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__nor2_1
XFILLER_20_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07154_ _01031_ _01032_ _01012_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07085_ net553 net470 net394 net378 VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__and4_1
X_06105_ _05232_ _05233_ _05172_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__a21oi_1
X_06036_ _05163_ _05165_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__nand2_1
XFILLER_87_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout179 net7 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_2
X_07987_ _01940_ _01941_ _01937_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__a21o_1
XFILLER_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout168 net169 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_2
X_06938_ net485 net339 VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__nand2_1
XFILLER_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09726_ _03726_ _03727_ _03729_ _03730_ _03731_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__a32o_1
XFILLER_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06869_ net440 net347 net580 net574 VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__and4_1
X_09657_ net351 net555 net539 net359 VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__a22o_1
X_08608_ _02618_ _02619_ _02455_ _02459_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__o211a_1
XFILLER_63_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09588_ _03525_ _03534_ _03533_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__a21o_1
X_08539_ _02382_ _02385_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__nor2_1
XFILLER_70_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10501_ _04580_ _04634_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__nand2_1
XFILLER_109_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10432_ _04606_ _04605_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_94_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10363_ _04530_ _04531_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__and2b_1
XFILLER_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10294_ _04457_ _04452_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__nand2b_1
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07910_ _01856_ _01858_ _01683_ _01686_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__a211o_1
XFILLER_69_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08890_ net161 net329 net321 net170 VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__a22o_1
XFILLER_110_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07841_ _01623_ _01625_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__nand2_1
XFILLER_29_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07772_ _01707_ _01706_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__nand2b_1
XFILLER_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06723_ _00564_ _00565_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__nand2_1
XFILLER_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09511_ _03602_ _03605_ _03482_ _03485_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__o211ai_2
XFILLER_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06654_ _00243_ _00488_ _00365_ _00363_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__and4bb_1
X_09442_ _03527_ _03528_ _03529_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__nand3_1
X_06585_ net191 net432 net388 net301 VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__and4_1
XFILLER_24_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05605_ _03428_ _03515_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__xnor2_1
X_09373_ net385 net253 VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__and2_1
X_08324_ _02308_ _02309_ _02310_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__nand3_1
X_05536_ net229 net471 net459 net235 VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__a22oi_1
XFILLER_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08255_ net547 net316 _02098_ _02096_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__a31o_1
X_05467_ _01999_ _02010_ _01464_ _01551_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__o211ai_2
X_07206_ _00975_ _00977_ _01089_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__o21a_1
X_08186_ net199 net558 net541 net208 VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__a22o_1
X_05398_ _00930_ _01257_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__xnor2_1
XFILLER_118_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07137_ _01014_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__nor2_1
XFILLER_118_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07068_ net498 net318 VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__nand2_1
XFILLER_58_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06019_ _05148_ _05149_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__nor2_1
XFILLER_59_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09709_ _03818_ _03820_ _03801_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__a21oi_1
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10415_ _04586_ _04587_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__nor2_1
XFILLER_99_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10346_ _04420_ _04421_ _04423_ _04426_ net591 VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__a32o_1
XFILLER_97_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10277_ _04363_ _04366_ _04438_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__o21ai_1
XFILLER_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap2 _00893_ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__buf_1
XFILLER_74_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06370_ _00098_ _00100_ _00188_ VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__nand3_2
X_05321_ net516 net234 net228 net605 VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__a22oi_1
X_08040_ _01997_ _01998_ _02001_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_116_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09991_ _03508_ _03509_ _03621_ _03737_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__a31oi_1
X_08942_ _02985_ _02986_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__or2_1
XFILLER_111_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08873_ _02908_ _02909_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__a21o_1
XFILLER_96_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07824_ net182 net393 net174 net377 VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__nand4_1
XFILLER_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07755_ _01528_ _01688_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__xnor2_1
XFILLER_71_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06706_ _00545_ _00546_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__and2b_1
X_07686_ _01611_ _01614_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06637_ _00348_ net148 _00470_ _00471_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__o211ai_4
X_09425_ net406 net509 net504 net413 VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__a22o_1
XFILLER_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06568_ _00390_ _00395_ VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__nand2b_1
X_09356_ _03433_ _03435_ _03420_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__o21ai_1
XFILLER_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08307_ _02150_ _02153_ _02290_ _02291_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__o211ai_1
X_06499_ _00314_ _00319_ VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__xnor2_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05519_ _02075_ _02577_ _02588_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__and3_1
X_09287_ _03226_ _03228_ _03360_ _03361_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__a211oi_4
X_08238_ net457 net279 net271 net474 VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__a22oi_1
XFILLER_60_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08169_ net427 net578 net575 net184 VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__a22oi_2
X_10200_ _04271_ _04273_ _04354_ _04355_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__a211o_1
X_10131_ _04193_ _04195_ _04279_ _04280_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__o211ai_4
X_10062_ _04202_ _04203_ _04061_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__o21ai_1
XFILLER_75_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xwire152 _03323_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_2
XFILLER_112_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10329_ _04416_ _04421_ _04495_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_111_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05870_ net606 net404 _05001_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__a21oi_1
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07540_ _01452_ _01454_ _01451_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__a21o_1
XFILLER_34_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07471_ _01250_ _01252_ _01251_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__o21ba_1
XFILLER_34_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06422_ _00241_ _00240_ VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_62_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09210_ net405 net532 net525 net413 VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__a22o_1
X_06353_ _00170_ _00171_ _00062_ _00065_ VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__o211a_1
X_09141_ _03201_ _03202_ net466 net260 VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__and4bb_1
X_09072_ _03127_ _03128_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__xnor2_1
XFILLER_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08023_ net208 net199 net564 net557 VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__nand4_1
X_06284_ _00103_ _00104_ VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__nor2_1
XFILLER_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09974_ _04024_ _04108_ _04109_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__or3_1
XFILLER_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08925_ _02925_ _02926_ _02966_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__nor4_1
XFILLER_97_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08856_ _02889_ _02890_ _02732_ _02734_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__a211o_1
X_07807_ net548 net444 net332 net325 VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__and4_1
XFILLER_17_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08787_ _02793_ _02815_ _02816_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__and3_1
XFILLER_57_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05999_ _05033_ _05041_ _05040_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__a21bo_1
X_07738_ _01630_ _01631_ _01667_ _01668_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__a22o_1
XFILLER_111_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07669_ _01588_ _01594_ _01596_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__nand3_1
XFILLER_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09408_ _03493_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__inv_2
XFILLER_9_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09339_ _03416_ _03418_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_23_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10114_ _04259_ _04260_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__xor2_1
XFILLER_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10045_ net581 net284 _04184_ _04185_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_59_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_2 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout509 net515 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__buf_2
X_06971_ _00835_ _00836_ VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__nor2_1
X_08710_ _02728_ _02729_ _02569_ _02571_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__a211o_1
X_09690_ _03631_ _03640_ _03639_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__a21o_1
X_05922_ _05017_ _05018_ _05050_ _05051_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__a22oi_1
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08641_ _02655_ _02656_ _02646_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__a21o_1
X_05853_ _04908_ _04984_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__nand2_1
XFILLER_39_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08572_ _02538_ _02581_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__xor2_1
XFILLER_25_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05784_ _04856_ _04863_ _04730_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__o21ai_2
X_07523_ _01275_ _01277_ _01434_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__and3_1
XFILLER_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07454_ _01218_ _01359_ _01361_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__or3_2
XFILLER_34_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06405_ _00221_ _00222_ _00204_ VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__a21oi_2
X_07385_ _01283_ _01284_ _01124_ _01127_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_20_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06336_ net484 net397 net380 net492 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__a22oi_1
X_09124_ _03184_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__inv_2
X_06267_ _05283_ _05285_ _00086_ _00087_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__o211a_1
X_09055_ _03107_ _03108_ _02884_ _02886_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__a211o_1
X_08006_ net427 net586 net578 net184 VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__a22o_1
XFILLER_104_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06198_ _05289_ _05291_ _00017_ _00018_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__or4_1
XFILLER_104_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09957_ _04083_ _04089_ _04090_ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__nand3_2
XFILLER_106_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08908_ net367 net594 _02947_ _02948_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__a22o_1
X_09888_ _04013_ _04014_ _03915_ _03917_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_86_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08839_ _02870_ _02871_ _02867_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_28_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10663_ _04851_ _04852_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__nand2b_1
XFILLER_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10594_ _04778_ _04779_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_97_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput94 net94 VGND VGND VPWR VPWR C[36] sky130_fd_sc_hd__buf_2
Xoutput83 net83 VGND VGND VPWR VPWR C[26] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput72 net72 VGND VGND VPWR VPWR C[16] sky130_fd_sc_hd__buf_2
XFILLER_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10028_ _04166_ _04167_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__nor2_1
XFILLER_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07170_ _00791_ _00793_ _01051_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__o211ai_4
XFILLER_117_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06121_ _05164_ _05075_ _05163_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__and3b_1
X_06052_ net453 net190 net433 net463 VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__a22o_1
XFILLER_8_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_2
Xfanout339 net341 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout328 net329 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_2
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_4
X_09811_ _03929_ _03931_ _03783_ _03829_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_70_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09742_ _03855_ _03856_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__xnor2_1
X_06954_ _00813_ _00816_ _00817_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__nand3_1
XFILLER_55_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06885_ _00739_ _00741_ _00597_ _00600_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__o211ai_1
X_05905_ _05034_ _05035_ _05036_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__or3_1
X_09673_ _03665_ _03782_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__and2b_1
X_08624_ _02629_ _02637_ _02638_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__nand3_1
XFILLER_54_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05836_ _04950_ _04967_ _04968_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__and3_1
X_08555_ net547 net286 _02560_ _02561_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_53_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05767_ _04136_ _04494_ _04483_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__o21bai_1
X_07506_ _01415_ _01416_ _01417_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__and3_1
XFILLER_23_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08486_ net214 net512 net506 net227 VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__a22oi_1
X_05698_ _04516_ _04526_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_81_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07437_ _01339_ _01340_ _01320_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07368_ _01133_ _01135_ _01134_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__o21ba_1
XFILLER_22_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06319_ _00032_ _00138_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__nor2_1
X_09107_ _03030_ _03031_ _03029_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__a21bo_1
X_07299_ _01152_ _01153_ _01190_ _01191_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__a22oi_2
X_09038_ net299 net285 _03088_ _03089_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__nand4_2
XFILLER_104_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10646_ _04747_ _04825_ _04833_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__and3_1
XFILLER_41_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10577_ _04760_ _04761_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__and2_1
XFILLER_54_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06670_ net484 net491 net365 net357 VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__and4_1
XFILLER_91_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05621_ _02818_ _02905_ _02894_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__a21bo_1
XFILLER_91_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08340_ _02322_ _02327_ _02328_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__nand3_1
X_05552_ _02916_ _02927_ _02938_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__a21o_1
XFILLER_32_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08271_ _02250_ _02251_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__xnor2_1
X_05483_ net494 net517 net206 net201 VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__and4_1
X_07222_ _01099_ _01108_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__and2_1
XFILLER_20_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07153_ _01012_ _01031_ _01032_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__nand3_1
XFILLER_118_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06104_ _05172_ _05232_ _05233_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__and3_1
XFILLER_118_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07084_ net449 net371 VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__nand2_1
X_06035_ _05157_ _05162_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__nand2_1
XFILLER_113_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07986_ _01937_ _01940_ _01941_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__nand3_1
Xfanout169 net171 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
X_06937_ _00795_ _00798_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__xnor2_1
XFILLER_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09725_ _03838_ _03839_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__nand2_1
XFILLER_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09656_ net359 net351 net555 net539 VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_38_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08607_ _02455_ _02459_ _02618_ _02619_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__a211oi_2
XFILLER_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06868_ net255 net588 VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__nand2_1
XFILLER_27_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06799_ net485 net477 net364 net356 VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__and4_1
XFILLER_82_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05819_ net231 net550 net467 net241 VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__a22oi_1
X_09587_ _03686_ _03687_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__xnor2_1
X_08538_ _02542_ _02543_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__nor2_1
XFILLER_23_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08469_ net408 net585 net578 net416 VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__a22o_1
XFILLER_23_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10500_ _04679_ _04680_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nor2_1
XFILLER_109_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10431_ _04542_ _04544_ _04541_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_94_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10362_ _04467_ _04468_ _04465_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__o21ai_2
X_10293_ _04138_ _04456_ _04455_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__a21oi_1
XFILLER_78_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10629_ _04815_ _04817_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07840_ _01745_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07771_ _01531_ _01533_ _01530_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__o21ba_1
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06722_ _00562_ _00563_ _00422_ _00424_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09510_ _03482_ _03485_ _03602_ _03605_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__a211o_1
XFILLER_37_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06653_ _00363_ _00488_ VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__xor2_1
XFILLER_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09441_ _03527_ _03528_ _03529_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__a21o_1
XFILLER_24_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06584_ _00412_ _00413_ VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__xnor2_1
X_05604_ _03428_ _03515_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__nand2b_1
X_09372_ _03452_ _03453_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__xnor2_1
X_08323_ _02140_ _02142_ _02141_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__o21bai_1
X_05535_ net235 net229 net471 net459 VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__and4_1
XFILLER_20_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08254_ _02073_ _02077_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__nand2_1
X_05466_ _01464_ _01551_ _01999_ _02010_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07205_ _00975_ _00977_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__nor3_1
X_08185_ net208 net199 net558 net541 VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand4_1
X_05397_ _00669_ _01257_ _00909_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__or3b_1
X_07136_ net227 net587 net582 net237 VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__a22oi_1
X_07067_ _00787_ _00938_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_18_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06018_ _05146_ _05147_ _05062_ _05064_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__a211oi_2
XFILLER_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07969_ _01921_ _01923_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__xnor2_1
X_09708_ _03801_ _03818_ _03820_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__and3_2
XFILLER_28_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09639_ net376 net528 net515 net395 VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__a22oi_1
XFILLER_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10414_ net306 net502 _04522_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_36_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10345_ _04510_ _04511_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10276_ _04368_ _04437_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_45_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05320_ net516 net234 net228 net605 VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_54_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09990_ _04126_ _04127_ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__nor2_1
X_08941_ _02694_ _02837_ _02836_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__a21oi_1
X_08872_ net424 net542 VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__and2_1
XFILLER_111_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07823_ net401 net174 _01613_ _01612_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_63_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07754_ _01528_ _01688_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__nand2b_1
X_06705_ net469 net418 net410 net552 VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__a22o_1
X_07685_ _01612_ _01613_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__and2b_1
XFILLER_71_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06636_ _00428_ _00431_ _00467_ _00468_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__o22ai_2
XFILLER_80_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09424_ net413 net405 net509 net504 VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__and4_1
XFILLER_25_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06567_ _00393_ _00394_ VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__xnor2_1
X_09355_ _03420_ _03433_ _03435_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__or3_1
X_08306_ _02288_ _02289_ _02275_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__o21ai_1
X_06498_ _00314_ _00319_ VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_72_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05518_ _02555_ _02566_ _02021_ _02053_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__o211ai_1
X_09286_ _03358_ _03359_ _03348_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__a21oi_2
X_08237_ net474 net457 net279 net271 VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__and4_1
X_05449_ _01758_ _01769_ _01824_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__nand3_1
XFILLER_119_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08168_ net184 net427 net578 net571 VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__and4_1
XFILLER_106_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08099_ _01880_ _01883_ _02063_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__a21oi_1
X_07119_ _00863_ _00866_ _00994_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__a21o_1
XFILLER_79_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10130_ _04275_ _04276_ _04188_ _04191_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10061_ _04061_ _04202_ _04203_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__or3_1
XFILLER_87_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10328_ _04492_ _04493_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nand2_1
XFILLER_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10259_ _04417_ _04419_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__or2_1
XFILLER_38_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07470_ _01226_ _01228_ _01225_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__o21ba_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06421_ _00130_ _00131_ _00133_ _00134_ _00045_ VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__a32oi_2
XFILLER_34_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06352_ _00062_ _00065_ _00170_ _00171_ VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__a211oi_2
X_09140_ net466 net260 _03201_ _03202_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__o2bb2a_1
X_09071_ _02988_ _02992_ _02987_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__a21bo_1
X_06283_ net231 net180 net172 net240 VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__a22oi_1
X_08022_ _01819_ _01821_ _01820_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__o21bai_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09973_ _04061_ _04062_ _04106_ _04107_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__a22oi_1
XFILLER_103_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08924_ _02964_ _02965_ _02772_ _02776_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__o211a_1
X_08855_ _02732_ _02734_ _02889_ _02890_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__o211ai_4
X_07806_ _01600_ _01602_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__nor2_1
X_08786_ _02813_ _02814_ _02794_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07737_ _01630_ _01631_ _01667_ _01668_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__nand4_2
XFILLER_72_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05998_ _05126_ _05127_ _05119_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__a21o_1
XFILLER_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07668_ _01592_ _01593_ _01589_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__a21o_1
XFILLER_52_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07599_ _01360_ _01362_ _01518_ _01520_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__a211o_2
XFILLER_80_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_80_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06619_ _00449_ _00450_ _00452_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__or3_1
X_09407_ _03329_ _03376_ _03491_ _03492_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__a211oi_2
X_09338_ _03413_ _03414_ _03415_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09269_ _03208_ _03209_ _03207_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10113_ _04259_ _04260_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__or2_1
X_10044_ net581 net284 _04184_ _04185_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__a22o_1
XFILLER_0_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_3 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06970_ net418 net303 net410 net389 VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__a22oi_1
XFILLER_39_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05921_ _05017_ _05018_ _05050_ _05051_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nand4_1
XFILLER_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08640_ _02646_ _02655_ _02656_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__nand3_1
X_05852_ _04908_ _04984_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__or2_1
XFILLER_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08571_ _02539_ _02579_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__xnor2_1
XFILLER_81_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05783_ _04624_ _04912_ _04915_ _04698_ VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__o22ai_2
XFILLER_19_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07522_ _01275_ _01277_ _01434_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__a21o_1
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07453_ _01357_ _01358_ _01199_ _01201_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__o211a_1
X_06404_ _00204_ _00221_ _00222_ VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__nand3_2
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07384_ _01124_ _01127_ _01283_ _01284_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__a211oi_2
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09123_ _03181_ _03182_ _03183_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__and3_1
X_06335_ net484 net492 net397 net380 VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__and4_1
X_06266_ _05299_ _05301_ _00085_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__nand3_2
X_09054_ _02884_ _02886_ _03107_ _03108_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__o211ai_4
XFILLER_116_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08005_ net184 net427 net585 net578 VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__nand4_1
XFILLER_104_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06197_ _05289_ _05291_ _00017_ _00018_ VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__nor4_1
XFILLER_2_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09956_ _04087_ _04088_ _04084_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__a21o_1
XFILLER_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08907_ net375 net586 net579 net392 VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__a22o_1
X_09887_ _03915_ _03917_ _04013_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__a211o_1
XFILLER_66_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08838_ _02867_ _02870_ _02871_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__nand3_2
XFILLER_57_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08769_ net406 net572 net564 net414 VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__a22o_1
XFILLER_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10662_ _04835_ _04839_ _04850_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__or3b_1
XFILLER_41_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10593_ net531 net250 _04737_ _04736_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__a31oi_2
XFILLER_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput84 net84 VGND VGND VPWR VPWR C[27] sky130_fd_sc_hd__buf_2
XFILLER_95_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput73 net73 VGND VGND VPWR VPWR C[17] sky130_fd_sc_hd__buf_2
Xoutput95 net95 VGND VGND VPWR VPWR C[37] sky130_fd_sc_hd__buf_2
XFILLER_0_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10027_ _04164_ _04165_ net599 net261 VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__and4bb_1
XFILLER_48_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06120_ _05078_ _05169_ _05170_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__o21a_1
XFILLER_117_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06051_ net460 net453 net190 net433 VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__nand4_1
XFILLER_99_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_4
XFILLER_98_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout329 net330 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_4
X_09810_ _03932_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__inv_2
Xfanout307 net49 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_4
X_06953_ net454 net371 _00814_ _00815_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__a22o_1
X_09741_ _03856_ _03855_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__nand2b_1
X_05904_ net346 net224 net183 net439 VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__a22oi_2
XFILLER_94_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06884_ _00597_ _00600_ _00739_ _00741_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__a211o_1
X_09672_ _03625_ _03780_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08623_ _02634_ _02635_ _02636_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a21o_1
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05835_ _04964_ _04965_ _04966_ VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__a21o_1
X_08554_ net547 net286 _02560_ _02561_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_53_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05766_ _04863_ _04864_ _04897_ _04898_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_42_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07505_ _01255_ _01258_ _01256_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_53_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08485_ _02484_ _02485_ _02465_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__a21o_1
XFILLER_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05697_ _04516_ _04526_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__and2_1
XFILLER_23_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07436_ _01320_ _01339_ _01340_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__nand3_2
XFILLER_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07367_ net553 net370 _01118_ _01116_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__a31o_1
X_06318_ _00032_ _00138_ VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__and2_1
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09106_ _03161_ _03162_ _03163_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__nand3_1
X_07298_ _01152_ _01153_ _01190_ _01191_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__and4_1
X_09037_ net299 net285 _03088_ _03089_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__a22o_1
X_06249_ _00067_ _00068_ _00046_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__o21a_1
XFILLER_89_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09939_ net626 net249 VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__nand2_1
XFILLER_85_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10645_ _04747_ _04825_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10576_ _04672_ _04716_ _04721_ _04687_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__a22o_1
XFILLER_107_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05620_ _03668_ _03679_ _03592_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__a21o_1
XFILLER_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05551_ _02916_ _02927_ _02938_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__nand3_2
X_08270_ _02251_ _02250_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand2b_1
X_05482_ net604 net196 VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__nand2_1
XFILLER_32_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07221_ _01105_ _01106_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_30_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07152_ _01012_ _01031_ _01032_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__and3_1
XFILLER_20_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06103_ _05230_ _05231_ _05136_ _05138_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__a211o_1
X_07083_ _00834_ _00836_ _00835_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__o21ba_1
X_06034_ _05157_ _05162_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__and2_1
XFILLER_113_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07985_ net179 net369 _01938_ _01939_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__nand4_1
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
X_06936_ _00796_ _00797_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__and2b_1
X_09724_ _03836_ _03837_ _03685_ _03688_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__o211ai_1
XFILLER_95_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06867_ _00721_ _00722_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__xnor2_1
X_09655_ _03761_ _03762_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_38_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08606_ _02615_ _02617_ _02484_ _02486_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__o211a_1
X_05818_ net241 net231 net550 net467 VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__and4_1
X_06798_ _00645_ _00646_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09586_ net297 net242 _03686_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__nand3_1
XFILLER_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08537_ _02540_ _02541_ net457 net264 VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__and4bb_1
X_05749_ net346 net386 net300 net439 VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__a22oi_2
X_08468_ net416 net408 net585 net578 VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__and4_1
X_07419_ net233 net574 net567 net236 VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__a22oi_1
XFILLER_23_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08399_ _02389_ _02390_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__xor2_1
X_10430_ _04603_ _04604_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10361_ _04462_ _04529_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__xnor2_1
X_10292_ _04311_ _04453_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__nor2_1
XFILLER_104_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10628_ _04789_ _04793_ _04814_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__nor3_1
XFILLER_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10559_ _04740_ _04742_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__nor2_1
XFILLER_115_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07770_ _01704_ _01705_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__xnor2_1
XFILLER_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06721_ _00422_ _00424_ _00562_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_69_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09440_ net336 net576 VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__and2_1
X_06652_ _00363_ _00488_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__nor2_1
XFILLER_52_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06583_ net454 net403 VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__nand2_1
X_05603_ _03439_ _03494_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__xnor2_1
X_09371_ _03453_ _03452_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__and2b_1
X_08322_ _02306_ _02307_ _02305_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__o21ai_1
X_05534_ _02654_ _02741_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__xnor2_1
XFILLER_33_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08253_ _02101_ _02110_ _02109_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__a21o_1
XFILLER_20_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07204_ _01086_ _01087_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__xor2_1
X_05465_ _01867_ _01878_ _01988_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__o21a_1
XFILLER_118_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08184_ net194 net565 VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__nand2_1
X_05396_ _01224_ _01235_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__xnor2_1
XFILLER_118_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07135_ net237 net227 net587 net582 VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__and4_1
XFILLER_109_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07066_ _00787_ _00938_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__nand2_1
X_06017_ _05062_ _05064_ _05146_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__o211a_1
XFILLER_101_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07968_ net444 net317 VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__nand2_1
X_06919_ _00775_ _00776_ _00779_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__and3_1
XFILLER_74_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09707_ _03816_ _03817_ _03704_ _03706_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__o211ai_1
XFILLER_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07899_ _01783_ _01845_ _01847_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__and3_1
XFILLER_90_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09638_ net392 net375 net528 net515 VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__and4_1
X_09569_ _03669_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__inv_2
XFILLER_43_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10413_ net306 net502 _04522_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__a21oi_1
X_10344_ _04510_ _04511_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__and2b_1
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10275_ _04389_ _04435_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__xnor2_1
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout490 net27 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_100_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08940_ _02846_ _02984_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_75_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08871_ net430 net533 net527 net186 VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__a22o_1
X_07822_ _01590_ _01593_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__nand2_1
XFILLER_69_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07753_ _01686_ _01687_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__nor2_1
XFILLER_65_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06704_ net552 net469 net418 net410 VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__and4_1
X_07684_ net408 net166 net621 net416 VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__a22o_1
XFILLER_65_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06635_ _00428_ _00431_ _00467_ _00468_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__or4_2
XFILLER_52_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09423_ _03508_ _03510_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__xor2_1
XFILLER_12_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09354_ _03430_ _03431_ _03432_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__a21oi_1
X_06566_ net484 net372 VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__nand2_1
X_08305_ _02275_ _02288_ _02289_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__or3_1
X_06497_ _00317_ _00318_ VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__xnor2_1
X_05517_ _02021_ _02053_ _02555_ _02566_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__a211o_1
XFILLER_20_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09285_ _03348_ _03358_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__and3_2
X_08236_ _02095_ _02132_ _02129_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__o21ai_1
X_05448_ _01802_ _01813_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__xnor2_1
X_08167_ net422 net586 VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__nand2_1
XFILLER_119_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07118_ _00863_ _00866_ _00994_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__a21oi_1
X_05379_ net605 net217 VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__nand2_1
XFILLER_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08098_ _01880_ _01883_ _02063_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__and3_1
XFILLER_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07049_ net520 net608 net310 net295 VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__nand4_1
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10060_ _04061_ _04202_ _04203_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__nor3_1
XFILLER_102_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10327_ _04490_ _04491_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10258_ net583 net250 VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__and2_1
XFILLER_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10189_ net296 net560 net545 net49 VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__a22o_1
XFILLER_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06420_ _00144_ _00238_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__xnor2_1
XFILLER_61_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06351_ _00167_ _00169_ _00086_ _00089_ VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__o211a_1
X_09070_ _03125_ _03126_ VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__xnor2_1
X_06282_ net240 net230 net180 net172 VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__and4_1
X_08021_ _01811_ _01814_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__nand2_1
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09972_ _04061_ _04062_ _04106_ _04107_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__and4_1
XFILLER_103_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08923_ _02772_ _02776_ _02964_ _02965_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__a211oi_4
XFILLER_97_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08854_ _02887_ _02888_ _02778_ _02780_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__a211o_1
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07805_ _01699_ _01743_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__xor2_1
X_08785_ _02794_ _02813_ _02814_ VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__nand3_2
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05997_ _05119_ _05126_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__nand3_1
XFILLER_84_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07736_ _01630_ _01631_ _01667_ _01668_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__and4_1
XFILLER_37_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07667_ _01589_ _01592_ _01593_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__nand3_1
XFILLER_80_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07598_ _01516_ _01517_ _01245_ _01248_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__o211a_1
XFILLER_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06618_ net348 net595 net587 net440 VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__a22oi_2
XFILLER_53_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09406_ _03445_ _03446_ _03489_ _03490_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__a2bb2oi_1
X_06549_ net610 net333 net326 net631 VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__a22o_1
X_09337_ _03413_ _03414_ _03415_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_23_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09268_ _03339_ _03340_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__xnor2_1
X_08219_ _02194_ _02196_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__nor2_1
XFILLER_5_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09199_ _03265_ _03267_ _03259_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__a21oi_1
XFILLER_106_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10112_ net614 net243 VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__nand2_1
XFILLER_102_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10043_ net307 net566 net292 net573 VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__a22o_1
XFILLER_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_4 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05920_ _05017_ _05018_ _05050_ _05051_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__and4_1
XFILLER_66_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05851_ _04981_ _04982_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__xnor2_1
XFILLER_94_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08570_ _02579_ _02539_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__and2b_1
X_07521_ _01275_ _01277_ _01434_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__a21oi_1
XFILLER_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05782_ _04698_ _04915_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__xor2_1
XFILLER_81_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07452_ _01199_ _01201_ _01357_ _01358_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__a211o_1
XFILLER_34_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07383_ _01281_ _01282_ _01150_ _01152_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__o211a_1
X_06403_ _00204_ _00221_ _00222_ VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__and3_1
XFILLER_22_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06334_ _00071_ _00073_ _00072_ VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__o21ba_1
X_09122_ _03040_ _03048_ _03046_ VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_20_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06265_ _05299_ _05301_ _00085_ VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__a21o_2
X_09053_ _03105_ _03106_ _02964_ _02966_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__a211o_1
X_08004_ _01960_ _01961_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__xnor2_1
X_06196_ _00014_ _00016_ _05222_ _05225_ VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__o211a_1
XFILLER_104_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09955_ _04084_ _04087_ _04088_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__nand3_2
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08906_ net392 net375 net586 net579 VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__nand4_1
X_09886_ _04011_ _04012_ _03910_ _03912_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__o211a_1
XFILLER_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08837_ net385 net286 _02868_ _02869_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_28_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08768_ net414 net406 net572 net564 VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__and4_1
XFILLER_26_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08699_ _02715_ _02718_ _02720_ VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__nand3_2
X_07719_ net437 net344 net529 net513 VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_0_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10661_ _04835_ _04839_ _04850_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__o21ba_1
XFILLER_41_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10592_ _04776_ _04777_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__xor2_1
XFILLER_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput85 net85 VGND VGND VPWR VPWR C[28] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR C[18] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput96 net96 VGND VGND VPWR VPWR C[38] sky130_fd_sc_hd__buf_2
XFILLER_76_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10026_ net599 net261 _04164_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_36_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06050_ net473 net425 VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__nand2_1
XFILLER_98_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout319 net48 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout308 net311 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_4
XFILLER_98_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06952_ net454 net371 _00814_ _00815_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__nand4_1
XFILLER_86_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09740_ _03750_ _03751_ _03749_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__a21boi_1
.ends
